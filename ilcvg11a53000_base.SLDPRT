ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(69.9999999999994,-16.0000000000196,-449.999999999978));
#20=DIRECTION('',(0.,-1.,0.));
#21=DIRECTION('',(0.,0.,-1.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=CONICAL_SURFACE('',#22,2.09999999993826,1.02974425828516);
#24=CARTESIAN_POINT('',(69.9999999999994,-16.0000000000325,-449.999999999978));
#25=DIRECTION('',(0.,-1.,0.));
#26=DIRECTION('',(0.,0.,-1.));
#27=AXIS2_PLACEMENT_3D('',#24,#25,#26);
#28=CIRCLE('',#27,2.09999999999998);
#29=CARTESIAN_POINT('',(69.9999999999994,-16.0000000000325,-452.099999999978));
#30=VERTEX_POINT('',#29);
#31=EDGE_CURVE('E669',#30,#30,#28,.T.);
#32=ORIENTED_EDGE('',*,*,#31,.T.);
#33=EDGE_LOOP('',(#32));
#34=FACE_BOUND('',#33,.T.);
#35=CARTESIAN_POINT('',(69.9999999999994,-14.7381926993262,-450.000000000273));
#36=VERTEX_POINT('',#35);
#37=VERTEX_LOOP('',#36);
#38=FACE_BOUND('',#37,.T.);
#39=ADVANCED_FACE('F35',(#34,#38),#23,.F.);
#40=CARTESIAN_POINT('',(-69.9999999999994,-15.9999999999059,-449.999999999978));
#41=DIRECTION('',(0.,-1.,0.));
#42=DIRECTION('',(0.,0.,-1.));
#43=AXIS2_PLACEMENT_3D('',#40,#41,#42);
#44=CONICAL_SURFACE('',#43,2.09999999971089,1.02974425827714);
#45=CARTESIAN_POINT('',(-69.9999999999994,-16.0000000000325,-449.999999999978));
#46=DIRECTION('',(0.,-1.,0.));
#47=DIRECTION('',(0.,0.,-1.));
#48=AXIS2_PLACEMENT_3D('',#45,#46,#47);
#49=CIRCLE('',#48,2.09999999999998);
#50=CARTESIAN_POINT('',(-69.9999999999994,-16.0000000000325,-452.099999999978));
#51=VERTEX_POINT('',#50);
#52=EDGE_CURVE('E666',#51,#51,#49,.T.);
#53=ORIENTED_EDGE('',*,*,#52,.T.);
#54=EDGE_LOOP('',(#53));
#55=FACE_BOUND('',#54,.T.);
#56=CARTESIAN_POINT('',(-69.9999999999994,-14.7381926993262,-450.000000000273));
#57=VERTEX_POINT('',#56);
#58=VERTEX_LOOP('',#57);
#59=FACE_BOUND('',#58,.T.);
#60=ADVANCED_FACE('F2966',(#55,#59),#44,.F.);
#61=CARTESIAN_POINT('',(0.,-15.999999999849,-579.999999999966));
#62=DIRECTION('',(0.,-1.,0.));
#63=DIRECTION('',(0.,0.,-1.));
#64=AXIS2_PLACEMENT_3D('',#61,#62,#63);
#65=CONICAL_SURFACE('',#64,2.10000000000254,1.02974425853096);
#66=CARTESIAN_POINT('',(0.,-15.9999999999335,-579.999999999966));
#67=DIRECTION('',(0.,-1.,0.));
#68=DIRECTION('',(0.,0.,-1.));
#69=AXIS2_PLACEMENT_3D('',#66,#67,#68);
#70=CIRCLE('',#69,2.09999999999998);
#71=CARTESIAN_POINT('',(0.,-15.9999999999335,-582.099999999966));
#72=VERTEX_POINT('',#71);
#73=EDGE_CURVE('E663',#72,#72,#70,.T.);
#74=ORIENTED_EDGE('',*,*,#73,.T.);
#75=EDGE_LOOP('',(#74));
#76=FACE_BOUND('',#75,.T.);
#77=CARTESIAN_POINT('',(0.,-14.7381926997809,-580.000000000183));
#78=VERTEX_POINT('',#77);
#79=VERTEX_LOOP('',#78);
#80=FACE_BOUND('',#79,.T.);
#81=ADVANCED_FACE('F2963',(#76,#80),#65,.F.);
#82=CARTESIAN_POINT('',(59.9999999999886,-11.9999999999436,-571.999999999998));
#83=DIRECTION('',(0.,1.,0.));
#84=DIRECTION('',(0.,0.,1.));
#85=AXIS2_PLACEMENT_3D('',#82,#83,#84);
#86=CONICAL_SURFACE('',#85,8.74999999984516,1.02974425863178);
#87=CARTESIAN_POINT('',(59.9999999999886,-11.9999999999672,-571.999999999998));
#88=DIRECTION('',(0.,1.,0.));
#89=DIRECTION('',(0.,0.,1.));
#90=AXIS2_PLACEMENT_3D('',#87,#88,#89);
#91=CIRCLE('',#90,8.75000000000056);
#92=CARTESIAN_POINT('',(59.9999999999886,-11.9999999999672,-563.249999999997));
#93=VERTEX_POINT('',#92);
#94=EDGE_CURVE('E660',#93,#93,#91,.T.);
#95=ORIENTED_EDGE('',*,*,#94,.T.);
#96=EDGE_LOOP('',(#95));
#97=FACE_BOUND('',#96,.T.);
#98=CARTESIAN_POINT('',(59.9999999999886,-17.2575304167424,-572.000000000055));
#99=VERTEX_POINT('',#98);
#100=VERTEX_LOOP('',#99);
#101=FACE_BOUND('',#100,.T.);
#102=ADVANCED_FACE('F2959',(#97,#101),#86,.F.);
#103=CARTESIAN_POINT('',(-59.9999999999886,-11.9999999999436,-571.999999999998));
#104=DIRECTION('',(0.,1.,0.));
#105=DIRECTION('',(0.,0.,1.));
#106=AXIS2_PLACEMENT_3D('',#103,#104,#105);
#107=CONICAL_SURFACE('',#106,8.74999999984516,1.02974425863178);
#108=CARTESIAN_POINT('',(-59.9999999999886,-11.9999999999672,-571.999999999998));
#109=DIRECTION('',(0.,1.,0.));
#110=DIRECTION('',(0.,0.,1.));
#111=AXIS2_PLACEMENT_3D('',#108,#109,#110);
#112=CIRCLE('',#111,8.75000000000056);
#113=CARTESIAN_POINT('',(-59.9999999999886,-11.9999999999672,-563.249999999997));
#114=VERTEX_POINT('',#113);
#115=EDGE_CURVE('E657',#114,#114,#112,.T.);
#116=ORIENTED_EDGE('',*,*,#115,.T.);
#117=EDGE_LOOP('',(#116));
#118=FACE_BOUND('',#117,.T.);
#119=CARTESIAN_POINT('',(-59.9999999999886,-17.2575304167424,-572.000000000055));
#120=VERTEX_POINT('',#119);
#121=VERTEX_LOOP('',#120);
#122=FACE_BOUND('',#121,.T.);
#123=ADVANCED_FACE('F2955',(#118,#122),#107,.F.);
#124=CARTESIAN_POINT('',(69.9999999999994,-30.000000000007,-449.999999999978));
#125=DIRECTION('',(0.,-1.,0.));
#126=DIRECTION('',(0.,0.,-1.));
#127=AXIS2_PLACEMENT_3D('',#124,#125,#126);
#128=CYLINDRICAL_SURFACE('',#127,2.09999999999998);
#129=CARTESIAN_POINT('',(69.9999999999994,-28.6999999999868,-449.999999999978));
#130=DIRECTION('',(0.,-1.,0.));
#131=DIRECTION('',(0.,0.,-1.));
#132=AXIS2_PLACEMENT_3D('',#129,#130,#131);
#133=CIRCLE('',#132,2.09999999999998);
#134=CARTESIAN_POINT('',(69.9999999999994,-28.6999999999868,-452.099999999978));
#135=VERTEX_POINT('',#134);
#136=EDGE_CURVE('E656',#135,#135,#133,.T.);
#137=ORIENTED_EDGE('',*,*,#136,.T.);
#138=EDGE_LOOP('',(#137));
#139=FACE_BOUND('',#138,.T.);
#140=ORIENTED_EDGE('',*,*,#31,.F.);
#141=EDGE_LOOP('',(#140));
#142=FACE_BOUND('',#141,.T.);
#143=ADVANCED_FACE('F2951',(#139,#142),#128,.F.);
#144=CARTESIAN_POINT('',(59.9999999999886,-12.0000000000573,-527.99999999992));
#145=DIRECTION('',(0.,1.,0.));
#146=DIRECTION('',(0.,0.,1.));
#147=AXIS2_PLACEMENT_3D('',#144,#145,#146);
#148=CONICAL_SURFACE('',#147,8.75000000003412,1.02974425865232);
#149=CARTESIAN_POINT('',(59.9999999999886,-11.9999999999926,-527.99999999992));
#150=DIRECTION('',(0.,1.,0.));
#151=DIRECTION('',(0.,0.,1.));
#152=AXIS2_PLACEMENT_3D('',#149,#150,#151);
#153=CIRCLE('',#152,8.75000000000056);
#154=CARTESIAN_POINT('',(59.9999999999886,-11.9999999999926,-519.249999999919));
#155=VERTEX_POINT('',#154);
#156=EDGE_CURVE('E653',#155,#155,#153,.T.);
#157=ORIENTED_EDGE('',*,*,#156,.T.);
#158=EDGE_LOOP('',(#157));
#159=FACE_BOUND('',#158,.T.);
#160=CARTESIAN_POINT('',(59.9999999999886,-17.2575304167992,-527.999999999849));
#161=VERTEX_POINT('',#160);
#162=VERTEX_LOOP('',#161);
#163=FACE_BOUND('',#162,.T.);
#164=ADVANCED_FACE('F2947',(#159,#163),#148,.F.);
#165=CARTESIAN_POINT('',(-59.9999999999886,-12.0000000000573,-527.99999999992));
#166=DIRECTION('',(0.,1.,0.));
#167=DIRECTION('',(0.,0.,1.));
#168=AXIS2_PLACEMENT_3D('',#165,#166,#167);
#169=CONICAL_SURFACE('',#168,8.75000000003412,1.02974425865232);
#170=CARTESIAN_POINT('',(-59.9999999999886,-11.9999999999825,-527.99999999992));
#171=DIRECTION('',(0.,1.,0.));
#172=DIRECTION('',(0.,0.,1.));
#173=AXIS2_PLACEMENT_3D('',#170,#171,#172);
#174=CIRCLE('',#173,8.75000000000056);
#175=CARTESIAN_POINT('',(-59.9999999999886,-11.9999999999825,-519.249999999919));
#176=VERTEX_POINT('',#175);
#177=EDGE_CURVE('E650',#176,#176,#174,.T.);
#178=ORIENTED_EDGE('',*,*,#177,.T.);
#179=EDGE_LOOP('',(#178));
#180=FACE_BOUND('',#179,.T.);
#181=CARTESIAN_POINT('',(-59.9999999999886,-17.2575304167992,-527.999999999849));
#182=VERTEX_POINT('',#181);
#183=VERTEX_LOOP('',#182);
#184=FACE_BOUND('',#183,.T.);
#185=ADVANCED_FACE('F2943',(#180,#184),#169,.F.);
#186=CARTESIAN_POINT('',(-69.9999999999994,-30.000000000007,-449.999999999978));
#187=DIRECTION('',(0.,-1.,0.));
#188=DIRECTION('',(0.,0.,-1.));
#189=AXIS2_PLACEMENT_3D('',#186,#187,#188);
#190=CYLINDRICAL_SURFACE('',#189,2.09999999999998);
#191=CARTESIAN_POINT('',(-69.9999999999994,-28.6999999999868,-449.999999999978));
#192=DIRECTION('',(0.,-1.,0.));
#193=DIRECTION('',(0.,0.,-1.));
#194=AXIS2_PLACEMENT_3D('',#191,#192,#193);
#195=CIRCLE('',#194,2.09999999999998);
#196=CARTESIAN_POINT('',(-69.9999999999994,-28.6999999999868,-452.099999999978));
#197=VERTEX_POINT('',#196);
#198=EDGE_CURVE('E649',#197,#197,#195,.T.);
#199=ORIENTED_EDGE('',*,*,#198,.T.);
#200=EDGE_LOOP('',(#199));
#201=FACE_BOUND('',#200,.T.);
#202=ORIENTED_EDGE('',*,*,#52,.F.);
#203=EDGE_LOOP('',(#202));
#204=FACE_BOUND('',#203,.T.);
#205=ADVANCED_FACE('F2939',(#201,#204),#190,.F.);
#206=CARTESIAN_POINT('',(0.,-29.9999999999816,-579.999999999966));
#207=DIRECTION('',(0.,-1.,0.));
#208=DIRECTION('',(0.,0.,-1.));
#209=AXIS2_PLACEMENT_3D('',#206,#207,#208);
#210=CYLINDRICAL_SURFACE('',#209,2.09999999999998);
#211=CARTESIAN_POINT('',(0.,-28.7000000000122,-579.999999999966));
#212=DIRECTION('',(0.,-1.,0.));
#213=DIRECTION('',(0.,0.,-1.));
#214=AXIS2_PLACEMENT_3D('',#211,#212,#213);
#215=CIRCLE('',#214,2.09999999999998);
#216=CARTESIAN_POINT('',(0.,-28.7000000000122,-582.099999999966));
#217=VERTEX_POINT('',#216);
#218=EDGE_CURVE('E648',#217,#217,#215,.T.);
#219=ORIENTED_EDGE('',*,*,#218,.T.);
#220=EDGE_LOOP('',(#219));
#221=FACE_BOUND('',#220,.T.);
#222=ORIENTED_EDGE('',*,*,#73,.F.);
#223=EDGE_LOOP('',(#222));
#224=FACE_BOUND('',#223,.T.);
#225=ADVANCED_FACE('F2935',(#221,#224),#210,.F.);
#226=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-571.999999999998));
#227=DIRECTION('',(0.,1.,0.));
#228=DIRECTION('',(0.,0.,1.));
#229=AXIS2_PLACEMENT_3D('',#226,#227,#228);
#230=CYLINDRICAL_SURFACE('',#229,8.75000000000056);
#231=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-571.999999999998));
#232=DIRECTION('',(0.,1.,0.));
#233=DIRECTION('',(0.,0.,1.));
#234=AXIS2_PLACEMENT_3D('',#231,#232,#233);
#235=CIRCLE('',#234,8.75000000000056);
#236=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-563.249999999997));
#237=VERTEX_POINT('',#236);
#238=EDGE_CURVE('E833',#237,#237,#235,.T.);
#239=ORIENTED_EDGE('',*,*,#238,.T.);
#240=EDGE_LOOP('',(#239));
#241=FACE_BOUND('',#240,.T.);
#242=ORIENTED_EDGE('',*,*,#94,.F.);
#243=EDGE_LOOP('',(#242));
#244=FACE_BOUND('',#243,.T.);
#245=ADVANCED_FACE('F2931',(#241,#244),#230,.F.);
#246=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-571.999999999998));
#247=DIRECTION('',(0.,1.,0.));
#248=DIRECTION('',(0.,0.,1.));
#249=AXIS2_PLACEMENT_3D('',#246,#247,#248);
#250=CYLINDRICAL_SURFACE('',#249,8.75000000000056);
#251=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-571.999999999998));
#252=DIRECTION('',(0.,1.,0.));
#253=DIRECTION('',(0.,0.,1.));
#254=AXIS2_PLACEMENT_3D('',#251,#252,#253);
#255=CIRCLE('',#254,8.75000000000056);
#256=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-563.249999999997));
#257=VERTEX_POINT('',#256);
#258=EDGE_CURVE('E830',#257,#257,#255,.T.);
#259=ORIENTED_EDGE('',*,*,#258,.T.);
#260=EDGE_LOOP('',(#259));
#261=FACE_BOUND('',#260,.T.);
#262=ORIENTED_EDGE('',*,*,#115,.F.);
#263=EDGE_LOOP('',(#262));
#264=FACE_BOUND('',#263,.T.);
#265=ADVANCED_FACE('F2927',(#261,#264),#250,.F.);
#266=CARTESIAN_POINT('',(0.,-35.0000000000124,-316.66666666667));
#267=DIRECTION('',(0.,-1.,0.));
#268=DIRECTION('',(0.,0.,-1.));
#269=AXIS2_PLACEMENT_3D('',#266,#267,#268);
#270=CYLINDRICAL_SURFACE('',#269,2.09999999999998);
#271=CARTESIAN_POINT('',(0.,-30.000000000007,-316.66666666667));
#272=DIRECTION('',(0.,-1.,0.));
#273=DIRECTION('',(0.,0.,-1.));
#274=AXIS2_PLACEMENT_3D('',#271,#272,#273);
#275=CIRCLE('',#274,2.09999999999998);
#276=CARTESIAN_POINT('',(0.,-30.000000000007,-318.76666666667));
#277=VERTEX_POINT('',#276);
#278=EDGE_CURVE('E827',#277,#277,#275,.F.);
#279=ORIENTED_EDGE('',*,*,#278,.F.);
#280=EDGE_LOOP('',(#279));
#281=FACE_BOUND('',#280,.T.);
#282=CARTESIAN_POINT('',(0.,-21.0000000000719,-316.66666666667));
#283=DIRECTION('',(0.,-1.,0.));
#284=DIRECTION('',(0.,0.,-1.));
#285=AXIS2_PLACEMENT_3D('',#282,#283,#284);
#286=CIRCLE('',#285,2.10000000020472);
#287=CARTESIAN_POINT('',(0.,-21.0000000000718,-318.766666666836));
#288=VERTEX_POINT('',#287);
#289=EDGE_CURVE('E645',#288,#288,#286,.F.);
#290=ORIENTED_EDGE('',*,*,#289,.T.);
#291=EDGE_LOOP('',(#290));
#292=FACE_BOUND('',#291,.T.);
#293=ADVANCED_FACE('F2923',(#281,#292),#270,.F.);
#294=CARTESIAN_POINT('',(69.9999999999994,-28.6999999999868,-449.999999999978));
#295=DIRECTION('',(0.,1.,0.));
#296=DIRECTION('',(0.,0.,1.));
#297=AXIS2_PLACEMENT_3D('',#294,#295,#296);
#298=PLANE('',#297);
#299=ORIENTED_EDGE('',*,*,#136,.F.);
#300=EDGE_LOOP('',(#299));
#301=FACE_BOUND('',#300,.T.);
#302=CARTESIAN_POINT('',(69.9999999999994,-28.6999999999868,-449.999999999978));
#303=DIRECTION('',(0.,-1.,0.));
#304=DIRECTION('',(0.,0.,-1.));
#305=AXIS2_PLACEMENT_3D('',#302,#303,#304);
#306=CIRCLE('',#305,2.49999999999991);
#307=CARTESIAN_POINT('',(69.9999999999994,-28.6999999999868,-452.499999999978));
#308=VERTEX_POINT('',#307);
#309=EDGE_CURVE('E824',#308,#308,#306,.T.);
#310=ORIENTED_EDGE('',*,*,#309,.T.);
#311=EDGE_LOOP('',(#310));
#312=FACE_BOUND('',#311,.T.);
#313=ADVANCED_FACE('F2919',(#301,#312),#298,.F.);
#314=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-527.99999999992));
#315=DIRECTION('',(0.,1.,0.));
#316=DIRECTION('',(0.,0.,1.));
#317=AXIS2_PLACEMENT_3D('',#314,#315,#316);
#318=CYLINDRICAL_SURFACE('',#317,8.75000000000056);
#319=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-527.99999999992));
#320=DIRECTION('',(0.,1.,0.));
#321=DIRECTION('',(0.,0.,1.));
#322=AXIS2_PLACEMENT_3D('',#319,#320,#321);
#323=CIRCLE('',#322,8.75000000000056);
#324=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-519.249999999919));
#325=VERTEX_POINT('',#324);
#326=EDGE_CURVE('E821',#325,#325,#323,.T.);
#327=ORIENTED_EDGE('',*,*,#326,.T.);
#328=EDGE_LOOP('',(#327));
#329=FACE_BOUND('',#328,.T.);
#330=ORIENTED_EDGE('',*,*,#156,.F.);
#331=EDGE_LOOP('',(#330));
#332=FACE_BOUND('',#331,.T.);
#333=ADVANCED_FACE('F2916',(#329,#332),#318,.F.);
#334=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-527.99999999992));
#335=DIRECTION('',(0.,1.,0.));
#336=DIRECTION('',(0.,0.,1.));
#337=AXIS2_PLACEMENT_3D('',#334,#335,#336);
#338=CYLINDRICAL_SURFACE('',#337,8.75000000000056);
#339=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-527.99999999992));
#340=DIRECTION('',(0.,1.,0.));
#341=DIRECTION('',(0.,0.,1.));
#342=AXIS2_PLACEMENT_3D('',#339,#340,#341);
#343=CIRCLE('',#342,8.75000000000056);
#344=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-519.249999999919));
#345=VERTEX_POINT('',#344);
#346=EDGE_CURVE('E818',#345,#345,#343,.T.);
#347=ORIENTED_EDGE('',*,*,#346,.T.);
#348=EDGE_LOOP('',(#347));
#349=FACE_BOUND('',#348,.T.);
#350=ORIENTED_EDGE('',*,*,#177,.F.);
#351=EDGE_LOOP('',(#350));
#352=FACE_BOUND('',#351,.T.);
#353=ADVANCED_FACE('F2628',(#349,#352),#338,.F.);
#354=CARTESIAN_POINT('',(-69.9999999999994,-28.6999999999868,-449.999999999978));
#355=DIRECTION('',(0.,1.,0.));
#356=DIRECTION('',(0.,0.,1.));
#357=AXIS2_PLACEMENT_3D('',#354,#355,#356);
#358=PLANE('',#357);
#359=ORIENTED_EDGE('',*,*,#198,.F.);
#360=EDGE_LOOP('',(#359));
#361=FACE_BOUND('',#360,.T.);
#362=CARTESIAN_POINT('',(-69.9999999999994,-28.6999999999868,-449.999999999978));
#363=DIRECTION('',(0.,-1.,0.));
#364=DIRECTION('',(0.,0.,-1.));
#365=AXIS2_PLACEMENT_3D('',#362,#363,#364);
#366=CIRCLE('',#365,2.49999999999991);
#367=CARTESIAN_POINT('',(-69.9999999999994,-28.6999999999868,-452.499999999978));
#368=VERTEX_POINT('',#367);
#369=EDGE_CURVE('E644',#368,#368,#366,.T.);
#370=ORIENTED_EDGE('',*,*,#369,.T.);
#371=EDGE_LOOP('',(#370));
#372=FACE_BOUND('',#371,.T.);
#373=ADVANCED_FACE('F2623',(#361,#372),#358,.F.);
#374=CARTESIAN_POINT('',(0.,-20.9999999999582,-316.66666666667));
#375=DIRECTION('',(0.,-1.,0.));
#376=DIRECTION('',(0.,0.,-1.));
#377=AXIS2_PLACEMENT_3D('',#374,#375,#376);
#378=CONICAL_SURFACE('',#377,2.09999999997734,1.02974425865096);
#379=CARTESIAN_POINT('',(0.,-20.0612478975586,-316.66666666667));
#380=DIRECTION('',(0.,1.,0.));
#381=DIRECTION('',(0.,0.,1.));
#382=AXIS2_PLACEMENT_3D('',#379,#380,#381);
#383=CIRCLE('',#382,0.537654137026777);
#384=CARTESIAN_POINT('',(0.,-20.0612478975586,-317.204320803701));
#385=VERTEX_POINT('',#384);
#386=EDGE_CURVE('E641',#385,#385,#383,.T.);
#387=CARTESIAN_POINT('',(0.,-21.0000000000718,-318.766666666836));
#388=CARTESIAN_POINT('',(0.,-20.9902213323373,-318.750392230762));
#389=CARTESIAN_POINT('',(0.,-20.9804426646028,-318.734117794688));
#390=CARTESIAN_POINT('',(0.,-20.9608853291338,-318.701568922539));
#391=CARTESIAN_POINT('',(0.,-20.9511066613993,-318.685294486465));
#392=CARTESIAN_POINT('',(0.,-20.9315493259303,-318.652745614316));
#393=CARTESIAN_POINT('',(0.,-20.9217706581957,-318.636471178242));
#394=CARTESIAN_POINT('',(0.,-20.9022133227267,-318.603922306093));
#395=CARTESIAN_POINT('',(0.,-20.8924346549922,-318.587647870019));
#396=CARTESIAN_POINT('',(0.,-20.8728773195232,-318.55509899787));
#397=CARTESIAN_POINT('',(0.,-20.8630986517887,-318.538824561796));
#398=CARTESIAN_POINT('',(0.,-20.8435413163196,-318.506275689647));
#399=CARTESIAN_POINT('',(0.,-20.8337626485851,-318.490001253573));
#400=CARTESIAN_POINT('',(0.,-20.8142053131161,-318.457452381424));
#401=CARTESIAN_POINT('',(0.,-20.8044266453816,-318.44117794535));
#402=CARTESIAN_POINT('',(0.,-20.7848693099126,-318.408629073201));
#403=CARTESIAN_POINT('',(0.,-20.775090642178,-318.392354637127));
#404=CARTESIAN_POINT('',(0.,-20.755533306709,-318.359805764978));
#405=CARTESIAN_POINT('',(0.,-20.7457546389745,-318.343531328904));
#406=CARTESIAN_POINT('',(0.,-20.7261973035055,-318.310982456755));
#407=CARTESIAN_POINT('',(0.,-20.716418635771,-318.294708020681));
#408=CARTESIAN_POINT('',(0.,-20.6968613003019,-318.262159148532));
#409=CARTESIAN_POINT('',(0.,-20.6870826325674,-318.245884712458));
#410=CARTESIAN_POINT('',(0.,-20.6675252970984,-318.213335840309));
#411=CARTESIAN_POINT('',(0.,-20.6577466293639,-318.197061404235));
#412=CARTESIAN_POINT('',(0.,-20.6381892938949,-318.164512532086));
#413=CARTESIAN_POINT('',(0.,-20.6284106261603,-318.148238096012));
#414=CARTESIAN_POINT('',(0.,-20.6088532906913,-318.115689223863));
#415=CARTESIAN_POINT('',(0.,-20.5990746229568,-318.099414787789));
#416=CARTESIAN_POINT('',(0.,-20.5795172874878,-318.066865915641));
#417=CARTESIAN_POINT('',(0.,-20.5697386197533,-318.050591479566));
#418=CARTESIAN_POINT('',(0.,-20.5501812842842,-318.018042607417));
#419=CARTESIAN_POINT('',(0.,-20.5404026165497,-318.001768171343));
#420=CARTESIAN_POINT('',(0.,-20.5208452810807,-317.969219299195));
#421=CARTESIAN_POINT('',(0.,-20.5110666133462,-317.95294486312));
#422=CARTESIAN_POINT('',(0.,-20.4915092778772,-317.920395990972));
#423=CARTESIAN_POINT('',(0.,-20.4817306101427,-317.904121554897));
#424=CARTESIAN_POINT('',(0.,-20.4621732746736,-317.871572682749));
#425=CARTESIAN_POINT('',(0.,-20.4523946069391,-317.855298246674));
#426=CARTESIAN_POINT('',(0.,-20.4328372714701,-317.822749374526));
#427=CARTESIAN_POINT('',(0.,-20.4230586037356,-317.806474938451));
#428=CARTESIAN_POINT('',(0.,-20.4035012682665,-317.773926066303));
#429=CARTESIAN_POINT('',(0.,-20.393722600532,-317.757651630228));
#430=CARTESIAN_POINT('',(0.,-20.374165265063,-317.72510275808));
#431=CARTESIAN_POINT('',(0.,-20.3643865973285,-317.708828322005));
#432=CARTESIAN_POINT('',(0.,-20.3448292618595,-317.676279449857));
#433=CARTESIAN_POINT('',(0.,-20.335050594125,-317.660005013782));
#434=CARTESIAN_POINT('',(0.,-20.3154932586559,-317.627456141634));
#435=CARTESIAN_POINT('',(0.,-20.3057145909214,-317.611181705559));
#436=CARTESIAN_POINT('',(0.,-20.2861572554524,-317.578632833411));
#437=CARTESIAN_POINT('',(0.,-20.2763785877179,-317.562358397336));
#438=CARTESIAN_POINT('',(0.,-20.2568212522489,-317.529809525188));
#439=CARTESIAN_POINT('',(0.,-20.2470425845143,-317.513535089113));
#440=CARTESIAN_POINT('',(0.,-20.2274852490453,-317.480986216965));
#441=CARTESIAN_POINT('',(0.,-20.2177065813108,-317.46471178089));
#442=CARTESIAN_POINT('',(0.,-20.1981492458418,-317.432162908742));
#443=CARTESIAN_POINT('',(0.,-20.1883705781073,-317.415888472667));
#444=CARTESIAN_POINT('',(0.,-20.1688132426382,-317.383339600519));
#445=CARTESIAN_POINT('',(0.,-20.1590345749037,-317.367065164444));
#446=CARTESIAN_POINT('',(0.,-20.1394772394347,-317.334516292296));
#447=CARTESIAN_POINT('',(0.,-20.1296985717002,-317.318241856222));
#448=CARTESIAN_POINT('',(0.,-20.1101412362312,-317.285692984073));
#449=CARTESIAN_POINT('',(0.,-20.1003625684966,-317.269418547998));
#450=CARTESIAN_POINT('',(0.,-20.0808052330276,-317.23686967585));
#451=CARTESIAN_POINT('',(0.,-20.0710265652931,-317.220595239776));
#452=CARTESIAN_POINT('',(0.,-20.0612478975586,-317.204320803701));
#453=B_SPLINE_CURVE_WITH_KNOTS('',3,(#387,#388,#389,#390,#391,#392,#393,#394,#395,#396,#397,
#398,#399,#400,#401,#402,#403,#404,#405,#406,#407,#408,#409,#410,#411,#412,#413,#414,#415,#416,
#417,#418,#419,#420,#421,#422,#423,#424,#425,#426,#427,#428,#429,#430,#431,#432,#433,#434,#435,
#436,#437,#438,#439,#440,#441,#442,#443,#444,#445,#446,#447,#448,#449,#450,#451,#452),
.UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.0569589019363419,0.113917803872686,0.170876705809029,0.227835607745373,0.284794509681717,
0.34175341161806,0.398712313554404,0.455671215490748,0.512630117427092,0.569589019363435,
0.626547921299779,0.683506823236123,0.740465725172466,0.79742462710881,0.854383529045154,
0.911342430981498,0.968301332917841,1.02526023485419,1.08221913679053,1.13917803872687,
1.19613694066322,1.25309584259956,1.3100547445359,1.36701364647225,1.42397254840859,
1.48093145034493,1.53789035228128,1.59484925421762,1.65180815615397,1.70876705809031,
1.76572596002665,1.822684861963),.UNSPECIFIED.);
#454=EDGE_CURVE('BSEAM2627',#288,#385,#453,.T.);
#455=ORIENTED_EDGE('',*,*,#289,.F.);
#456=ORIENTED_EDGE('',*,*,#386,.T.);
#457=ORIENTED_EDGE('',*,*,#454,.T.);
#458=ORIENTED_EDGE('',*,*,#454,.F.);
#459=EDGE_LOOP('',(#455,#457,#456,#458));
#460=FACE_BOUND('',#459,.T.);
#461=ADVANCED_FACE('F2627',(#460),#378,.F.);
#462=CARTESIAN_POINT('',(0.,-28.7000000000122,-579.999999999966));
#463=DIRECTION('',(0.,1.,0.));
#464=DIRECTION('',(0.,0.,1.));
#465=AXIS2_PLACEMENT_3D('',#462,#463,#464);
#466=PLANE('',#465);
#467=ORIENTED_EDGE('',*,*,#218,.F.);
#468=EDGE_LOOP('',(#467));
#469=FACE_BOUND('',#468,.T.);
#470=CARTESIAN_POINT('',(0.,-28.7000000000122,-579.999999999966));
#471=DIRECTION('',(0.,-1.,0.));
#472=DIRECTION('',(0.,0.,-1.));
#473=AXIS2_PLACEMENT_3D('',#470,#471,#472);
#474=CIRCLE('',#473,2.49999999999991);
#475=CARTESIAN_POINT('',(0.,-28.7000000000122,-582.499999999966));
#476=VERTEX_POINT('',#475);
#477=EDGE_CURVE('E638',#476,#476,#474,.T.);
#478=ORIENTED_EDGE('',*,*,#477,.T.);
#479=EDGE_LOOP('',(#478));
#480=FACE_BOUND('',#479,.T.);
#481=ADVANCED_FACE('F2641',(#469,#480),#466,.F.);
#482=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-571.999999999998));
#483=DIRECTION('',(0.,-1.,0.));
#484=DIRECTION('',(0.,0.,-1.));
#485=AXIS2_PLACEMENT_3D('',#482,#483,#484);
#486=PLANE('',#485);
#487=ORIENTED_EDGE('',*,*,#238,.F.);
#488=EDGE_LOOP('',(#487));
#489=FACE_BOUND('',#488,.T.);
#490=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-571.999999999998));
#491=DIRECTION('',(0.,1.,0.));
#492=DIRECTION('',(0.,0.,1.));
#493=AXIS2_PLACEMENT_3D('',#490,#491,#492);
#494=CIRCLE('',#493,10.0000000000006);
#495=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-561.999999999997));
#496=VERTEX_POINT('',#495);
#497=EDGE_CURVE('E810',#496,#496,#494,.T.);
#498=ORIENTED_EDGE('',*,*,#497,.T.);
#499=EDGE_LOOP('',(#498));
#500=FACE_BOUND('',#499,.T.);
#501=ADVANCED_FACE('F2651',(#489,#500),#486,.F.);
#502=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-571.999999999998));
#503=DIRECTION('',(0.,-1.,0.));
#504=DIRECTION('',(0.,0.,-1.));
#505=AXIS2_PLACEMENT_3D('',#502,#503,#504);
#506=PLANE('',#505);
#507=ORIENTED_EDGE('',*,*,#258,.F.);
#508=EDGE_LOOP('',(#507));
#509=FACE_BOUND('',#508,.T.);
#510=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-571.999999999998));
#511=DIRECTION('',(0.,1.,0.));
#512=DIRECTION('',(0.,0.,1.));
#513=AXIS2_PLACEMENT_3D('',#510,#511,#512);
#514=CIRCLE('',#513,10.0000000000006);
#515=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-561.999999999997));
#516=VERTEX_POINT('',#515);
#517=EDGE_CURVE('E807',#516,#516,#514,.T.);
#518=ORIENTED_EDGE('',*,*,#517,.T.);
#519=EDGE_LOOP('',(#518));
#520=FACE_BOUND('',#519,.T.);
#521=ADVANCED_FACE('F2660',(#509,#520),#506,.F.);
#522=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-457.999999999946));
#523=DIRECTION('',(0.,-1.,0.));
#524=DIRECTION('',(0.,0.,-1.));
#525=AXIS2_PLACEMENT_3D('',#522,#523,#524);
#526=PLANE('',#525);
#527=ORIENTED_EDGE('',*,*,#278,.T.);
#528=EDGE_LOOP('',(#527));
#529=FACE_BOUND('',#528,.T.);
#530=DIRECTION('',(0.,0.,-1.));
#531=VECTOR('',#530,1.);
#532=CARTESIAN_POINT('',(-8.00000000000102,-30.000000000007,-449.999999999978));
#533=LINE('',#532,#531);
#534=CARTESIAN_POINT('',(-8.0000000000067,-30.000000000007,-335.670000000018));
#535=VERTEX_POINT('',#534);
#536=CARTESIAN_POINT('',(-8.0000000000067,-30.000000000007,-298.666666666758));
#537=VERTEX_POINT('',#536);
#538=EDGE_CURVE('E1463',#535,#537,#533,.F.);
#539=ORIENTED_EDGE('',*,*,#538,.F.);
#540=CARTESIAN_POINT('',(0.,-30.000000000007,-341.67000000001));
#541=DIRECTION('',(0.,-1.,0.));
#542=DIRECTION('',(0.,0.,-1.));
#543=AXIS2_PLACEMENT_3D('',#540,#541,#542);
#544=CIRCLE('',#543,10.0000000000006);
#545=CARTESIAN_POINT('',(8.0000000000067,-30.000000000007,-335.670000000018));
#546=VERTEX_POINT('',#545);
#547=EDGE_CURVE('E799',#535,#546,#544,.F.);
#548=ORIENTED_EDGE('',*,*,#547,.T.);
#549=DIRECTION('',(0.,0.,1.));
#550=VECTOR('',#549,1.);
#551=CARTESIAN_POINT('',(8.00000000000102,-30.000000000007,-449.999999999978));
#552=LINE('',#551,#550);
#553=CARTESIAN_POINT('',(8.00000000000102,-30.000000000007,-298.666666666754));
#554=VERTEX_POINT('',#553);
#555=EDGE_CURVE('E1385',#554,#546,#552,.F.);
#556=ORIENTED_EDGE('',*,*,#555,.F.);
#557=CARTESIAN_POINT('',(0.,-30.000000000007,-292.666666666766));
#558=DIRECTION('',(0.,-1.,0.));
#559=DIRECTION('',(0.,0.,-1.));
#560=AXIS2_PLACEMENT_3D('',#557,#558,#559);
#561=CIRCLE('',#560,10.0000000000006);
#562=EDGE_CURVE('E803',#554,#537,#561,.F.);
#563=ORIENTED_EDGE('',*,*,#562,.T.);
#564=EDGE_LOOP('',(#539,#548,#556,#563));
#565=FACE_BOUND('',#564,.T.);
#566=ADVANCED_FACE('F1742',(#529,#565),#526,.T.);
#567=CARTESIAN_POINT('',(69.9999999999994,-29.9999999999816,-449.999999999978));
#568=DIRECTION('',(0.,-1.,0.));
#569=DIRECTION('',(0.,0.,-1.));
#570=AXIS2_PLACEMENT_3D('',#567,#568,#569);
#571=CYLINDRICAL_SURFACE('',#570,2.49999999999991);
#572=CARTESIAN_POINT('',(69.9999999999994,-29.9999999999816,-449.999999999978));
#573=DIRECTION('',(0.,-1.,0.));
#574=DIRECTION('',(0.,0.,-1.));
#575=AXIS2_PLACEMENT_3D('',#572,#573,#574);
#576=CIRCLE('',#575,2.49999999999991);
#577=CARTESIAN_POINT('',(69.9999999999994,-29.9999999999816,-452.499999999978));
#578=VERTEX_POINT('',#577);
#579=EDGE_CURVE('E784',#578,#578,#576,.F.);
#580=ORIENTED_EDGE('',*,*,#579,.F.);
#581=EDGE_LOOP('',(#580));
#582=FACE_BOUND('',#581,.T.);
#583=ORIENTED_EDGE('',*,*,#309,.F.);
#584=EDGE_LOOP('',(#583));
#585=FACE_BOUND('',#584,.T.);
#586=ADVANCED_FACE('F2678',(#582,#585),#571,.F.);
#587=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-527.99999999992));
#588=DIRECTION('',(0.,-1.,0.));
#589=DIRECTION('',(0.,0.,-1.));
#590=AXIS2_PLACEMENT_3D('',#587,#588,#589);
#591=PLANE('',#590);
#592=ORIENTED_EDGE('',*,*,#326,.F.);
#593=EDGE_LOOP('',(#592));
#594=FACE_BOUND('',#593,.T.);
#595=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-527.99999999992));
#596=DIRECTION('',(0.,1.,0.));
#597=DIRECTION('',(0.,0.,1.));
#598=AXIS2_PLACEMENT_3D('',#595,#596,#597);
#599=CIRCLE('',#598,10.0000000000006);
#600=CARTESIAN_POINT('',(59.9999999999886,30.000000000007,-517.999999999919));
#601=VERTEX_POINT('',#600);
#602=EDGE_CURVE('E779',#601,#601,#599,.T.);
#603=ORIENTED_EDGE('',*,*,#602,.T.);
#604=EDGE_LOOP('',(#603));
#605=FACE_BOUND('',#604,.T.);
#606=ADVANCED_FACE('F2595',(#594,#605),#591,.F.);
#607=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-527.99999999992));
#608=DIRECTION('',(0.,-1.,0.));
#609=DIRECTION('',(0.,0.,-1.));
#610=AXIS2_PLACEMENT_3D('',#607,#608,#609);
#611=PLANE('',#610);
#612=ORIENTED_EDGE('',*,*,#346,.F.);
#613=EDGE_LOOP('',(#612));
#614=FACE_BOUND('',#613,.T.);
#615=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-527.99999999992));
#616=DIRECTION('',(0.,1.,0.));
#617=DIRECTION('',(0.,0.,1.));
#618=AXIS2_PLACEMENT_3D('',#615,#616,#617);
#619=CIRCLE('',#618,10.0000000000006);
#620=CARTESIAN_POINT('',(-59.9999999999886,30.000000000007,-517.999999999919));
#621=VERTEX_POINT('',#620);
#622=EDGE_CURVE('E774',#621,#621,#619,.T.);
#623=ORIENTED_EDGE('',*,*,#622,.T.);
#624=EDGE_LOOP('',(#623));
#625=FACE_BOUND('',#624,.T.);
#626=ADVANCED_FACE('F2589',(#614,#625),#611,.F.);
#627=CARTESIAN_POINT('',(-69.9999999999994,-29.9999999999816,-449.999999999978));
#628=DIRECTION('',(0.,-1.,0.));
#629=DIRECTION('',(0.,0.,-1.));
#630=AXIS2_PLACEMENT_3D('',#627,#628,#629);
#631=CYLINDRICAL_SURFACE('',#630,2.49999999999991);
#632=CARTESIAN_POINT('',(-69.9999999999994,-29.9999999999816,-449.999999999978));
#633=DIRECTION('',(0.,-1.,0.));
#634=DIRECTION('',(0.,0.,-1.));
#635=AXIS2_PLACEMENT_3D('',#632,#633,#634);
#636=CIRCLE('',#635,2.49999999999991);
#637=CARTESIAN_POINT('',(-69.9999999999994,-29.9999999999816,-452.499999999978));
#638=VERTEX_POINT('',#637);
#639=EDGE_CURVE('E769',#638,#638,#636,.F.);
#640=ORIENTED_EDGE('',*,*,#639,.F.);
#641=EDGE_LOOP('',(#640));
#642=FACE_BOUND('',#641,.T.);
#643=ORIENTED_EDGE('',*,*,#369,.F.);
#644=EDGE_LOOP('',(#643));
#645=FACE_BOUND('',#644,.T.);
#646=ADVANCED_FACE('F2594',(#642,#645),#631,.F.);
#647=CARTESIAN_POINT('',(0.,-17.3800000001165,-69.0000000000034));
#648=DIRECTION('',(0.,1.,0.));
#649=DIRECTION('',(0.,0.,1.));
#650=AXIS2_PLACEMENT_3D('',#647,#648,#649);
#651=CONICAL_SURFACE('',#650,4.99999999981149,1.02974425853914);
#652=CARTESIAN_POINT('',(0.,-17.3800000000372,-69.0000000000034));
#653=DIRECTION('',(0.,1.,0.));
#654=DIRECTION('',(0.,0.,1.));
#655=AXIS2_PLACEMENT_3D('',#652,#653,#654);
#656=CIRCLE('',#655,5.00000000000032);
#657=CARTESIAN_POINT('',(0.,-17.3800000000372,-64.0000000000031));
#658=VERTEX_POINT('',#657);
#659=EDGE_CURVE('E1556',#658,#658,#656,.T.);
#660=ORIENTED_EDGE('',*,*,#659,.T.);
#661=EDGE_LOOP('',(#660));
#662=FACE_BOUND('',#661,.T.);
#663=CARTESIAN_POINT('',(0.,-20.3843030956534,-68.999999999761));
#664=VERTEX_POINT('',#663);
#665=VERTEX_LOOP('',#664);
#666=FACE_BOUND('',#665,.T.);
#667=ADVANCED_FACE('F2603',(#662,#666),#651,.F.);
#668=CARTESIAN_POINT('',(0.,-17.3800000000597,-109.499999999994));
#669=DIRECTION('',(0.,1.,0.));
#670=DIRECTION('',(0.,0.,1.));
#671=AXIS2_PLACEMENT_3D('',#668,#669,#670);
#672=CONICAL_SURFACE('',#671,4.99999999996378,1.02974425867524);
#673=CARTESIAN_POINT('',(0.,-17.3800000000397,-109.499999999994));
#674=DIRECTION('',(0.,1.,0.));
#675=DIRECTION('',(0.,0.,1.));
#676=AXIS2_PLACEMENT_3D('',#673,#674,#675);
#677=CIRCLE('',#676,5.00000000000032);
#678=CARTESIAN_POINT('',(0.,-17.3800000000397,-104.499999999993));
#679=VERTEX_POINT('',#678);
#680=EDGE_CURVE('E1553',#679,#679,#677,.T.);
#681=ORIENTED_EDGE('',*,*,#680,.T.);
#682=EDGE_LOOP('',(#681));
#683=FACE_BOUND('',#682,.T.);
#684=CARTESIAN_POINT('',(0.,-20.3843030951987,-109.500000000054));
#685=VERTEX_POINT('',#684);
#686=VERTEX_LOOP('',#685);
#687=FACE_BOUND('',#686,.T.);
#688=ADVANCED_FACE('F2608',(#683,#687),#672,.F.);
#689=CARTESIAN_POINT('',(0.,-17.3800000000028,-183.333333333311));
#690=DIRECTION('',(0.,1.,0.));
#691=DIRECTION('',(0.,0.,1.));
#692=AXIS2_PLACEMENT_3D('',#689,#690,#691);
#693=CONICAL_SURFACE('',#692,4.99999999985584,1.02974425867355);
#694=CARTESIAN_POINT('',(0.,-17.3799999999635,-183.333333333311));
#695=DIRECTION('',(0.,1.,0.));
#696=DIRECTION('',(0.,0.,1.));
#697=AXIS2_PLACEMENT_3D('',#694,#695,#696);
#698=CIRCLE('',#697,5.00000000000032);
#699=CARTESIAN_POINT('',(0.,-17.3799999999635,-178.333333333311));
#700=VERTEX_POINT('',#699);
#701=EDGE_CURVE('E1550',#700,#700,#698,.T.);
#702=ORIENTED_EDGE('',*,*,#701,.T.);
#703=EDGE_LOOP('',(#702));
#704=FACE_BOUND('',#703,.T.);
#705=CARTESIAN_POINT('',(0.,-20.3843030950566,-183.333333333422));
#706=VERTEX_POINT('',#705);
#707=VERTEX_LOOP('',#706);
#708=FACE_BOUND('',#707,.T.);
#709=ADVANCED_FACE('F2906',(#704,#708),#693,.F.);
#710=CARTESIAN_POINT('',(0.,-17.3800000001165,-216.666666666689));
#711=DIRECTION('',(0.,1.,0.));
#712=DIRECTION('',(0.,0.,1.));
#713=AXIS2_PLACEMENT_3D('',#710,#711,#712);
#714=CONICAL_SURFACE('',#713,4.99999999998746,1.02974425863708);
#715=CARTESIAN_POINT('',(0.,-17.3800000001032,-216.666666666689));
#716=DIRECTION('',(0.,1.,0.));
#717=DIRECTION('',(0.,0.,1.));
#718=AXIS2_PLACEMENT_3D('',#715,#716,#717);
#719=CIRCLE('',#718,5.00000000000032);
#720=CARTESIAN_POINT('',(0.,-17.3800000001032,-211.666666666689));
#721=VERTEX_POINT('',#720);
#722=EDGE_CURVE('E1547',#721,#721,#719,.T.);
#723=ORIENTED_EDGE('',*,*,#722,.T.);
#724=EDGE_LOOP('',(#723));
#725=FACE_BOUND('',#724,.T.);
#726=CARTESIAN_POINT('',(0.,-20.3843030955113,-216.666666666697));
#727=VERTEX_POINT('',#726);
#728=VERTEX_LOOP('',#727);
#729=FACE_BOUND('',#728,.T.);
#730=ADVANCED_FACE('F2910',(#725,#729),#714,.F.);
#731=CARTESIAN_POINT('',(0.,-17.3800000001165,-283.333333333216));
#732=DIRECTION('',(0.,1.,0.));
#733=DIRECTION('',(0.,0.,1.));
#734=AXIS2_PLACEMENT_3D('',#731,#732,#733);
#735=CONICAL_SURFACE('',#734,5.00000000013578,1.02974425867692);
#736=CARTESIAN_POINT('',(0.,-17.3800000001489,-283.333333333216));
#737=DIRECTION('',(0.,1.,0.));
#738=DIRECTION('',(0.,0.,1.));
#739=AXIS2_PLACEMENT_3D('',#736,#737,#738);
#740=CIRCLE('',#739,5.00000000000032);
#741=CARTESIAN_POINT('',(0.,-17.3800000001489,-278.333333333216));
#742=VERTEX_POINT('',#741);
#743=EDGE_CURVE('E1544',#742,#742,#740,.T.);
#744=ORIENTED_EDGE('',*,*,#743,.T.);
#745=EDGE_LOOP('',(#744));
#746=FACE_BOUND('',#745,.T.);
#747=CARTESIAN_POINT('',(0.,-20.3843030953124,-283.33333333336));
#748=VERTEX_POINT('',#747);
#749=VERTEX_LOOP('',#748);
#750=FACE_BOUND('',#749,.T.);
#751=ADVANCED_FACE('F3087',(#746,#750),#735,.F.);
#752=CARTESIAN_POINT('',(0.,-17.3800000001734,-316.66666666667));
#753=DIRECTION('',(0.,1.,0.));
#754=DIRECTION('',(0.,0.,1.));
#755=AXIS2_PLACEMENT_3D('',#752,#753,#754);
#756=CONICAL_SURFACE('',#755,4.99999999988887,1.0297442586876);
#757=CARTESIAN_POINT('',(0.,-17.3800000000676,-316.66666666667));
#758=DIRECTION('',(0.,1.,0.));
#759=DIRECTION('',(0.,0.,1.));
#760=AXIS2_PLACEMENT_3D('',#757,#758,#759);
#761=CIRCLE('',#760,5.00000000000032);
#762=CARTESIAN_POINT('',(0.,-17.3800000000676,-311.66666666667));
#763=VERTEX_POINT('',#762);
#764=EDGE_CURVE('E1437',#763,#763,#761,.T.);
#765=ORIENTED_EDGE('',*,*,#764,.T.);
#766=EDGE_LOOP('',(#765));
#767=FACE_BOUND('',#766,.T.);
#768=ORIENTED_EDGE('',*,*,#386,.F.);
#769=EDGE_LOOP('',(#768));
#770=FACE_BOUND('',#769,.T.);
#771=ADVANCED_FACE('F2707',(#767,#770),#756,.F.);
#772=CARTESIAN_POINT('',(0.,-29.5000000000344,-555.000000000066));
#773=DIRECTION('',(0.,-1.,0.));
#774=DIRECTION('',(0.,0.,-1.));
#775=AXIS2_PLACEMENT_3D('',#772,#773,#774);
#776=PLANE('',#775);
#777=CARTESIAN_POINT('',(0.,-29.5000000000344,-349.999999999906));
#778=DIRECTION('',(0.,-1.,0.));
#779=DIRECTION('',(0.,0.,-1.));
#780=AXIS2_PLACEMENT_3D('',#777,#778,#779);
#781=CIRCLE('',#780,8.00000000000001);
#782=CARTESIAN_POINT('',(0.,-29.5000000000344,-357.999999999906));
#783=VERTEX_POINT('',#782);
#784=EDGE_CURVE('E38',#783,#783,#781,.T.);
#785=ORIENTED_EDGE('',*,*,#784,.F.);
#786=EDGE_LOOP('',(#785));
#787=FACE_BOUND('',#786,.T.);
#788=CARTESIAN_POINT('',(0.,-29.5000000000344,-449.999999999906));
#789=DIRECTION('',(0.,-1.,0.));
#790=DIRECTION('',(0.,0.,-1.));
#791=AXIS2_PLACEMENT_3D('',#788,#789,#790);
#792=CIRCLE('',#791,8.50000000000001);
#793=CARTESIAN_POINT('',(0.,-29.5000000000344,-458.499999999906));
#794=VERTEX_POINT('',#793);
#795=EDGE_CURVE('E845',#794,#794,#792,.T.);
#796=ORIENTED_EDGE('',*,*,#795,.F.);
#797=EDGE_LOOP('',(#796));
#798=FACE_BOUND('',#797,.T.);
#799=DIRECTION('',(0.,0.,-1.));
#800=VECTOR('',#799,1.);
#801=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-555.000000000066));
#802=LINE('',#801,#800);
#803=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-440.000000000018));
#804=VERTEX_POINT('',#803);
#805=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-341.67000000001));
#806=VERTEX_POINT('',#805);
#807=EDGE_CURVE('E1373',#804,#806,#802,.F.);
#808=ORIENTED_EDGE('',*,*,#807,.T.);
#809=CARTESIAN_POINT('',(0.,-29.5000000000344,-341.67000000001));
#810=DIRECTION('',(0.,-1.,0.));
#811=DIRECTION('',(0.,0.,-1.));
#812=AXIS2_PLACEMENT_3D('',#809,#810,#811);
#813=CIRCLE('',#812,10.0000000000006);
#814=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-341.67000000001));
#815=VERTEX_POINT('',#814);
#816=EDGE_CURVE('E795',#806,#815,#813,.T.);
#817=ORIENTED_EDGE('',*,*,#816,.T.);
#818=DIRECTION('',(0.,0.,1.));
#819=VECTOR('',#818,1.);
#820=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-555.000000000066));
#821=LINE('',#820,#819);
#822=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-440.000000000018));
#823=VERTEX_POINT('',#822);
#824=EDGE_CURVE('E1430',#815,#823,#821,.F.);
#825=ORIENTED_EDGE('',*,*,#824,.T.);
#826=DIRECTION('',(1.,0.,0.));
#827=VECTOR('',#826,1.);
#828=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-440.000000000018));
#829=LINE('',#828,#827);
#830=CARTESIAN_POINT('',(-44.9999999999978,-29.5000000000344,-439.999999999998));
#831=VERTEX_POINT('',#830);
#832=EDGE_CURVE('E1304',#823,#831,#829,.F.);
#833=ORIENTED_EDGE('',*,*,#832,.T.);
#834=CARTESIAN_POINT('',(-44.9999999999978,-29.5000000000344,-449.999999999978));
#835=DIRECTION('',(0.,-1.,0.));
#836=DIRECTION('',(0.,0.,-1.));
#837=AXIS2_PLACEMENT_3D('',#834,#835,#836);
#838=CIRCLE('',#837,10.0000000000006);
#839=CARTESIAN_POINT('',(-44.9999999999978,-29.5000000000344,-459.999999999958));
#840=VERTEX_POINT('',#839);
#841=EDGE_CURVE('E760',#831,#840,#838,.T.);
#842=ORIENTED_EDGE('',*,*,#841,.T.);
#843=DIRECTION('',(-1.,0.,0.));
#844=VECTOR('',#843,1.);
#845=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-459.999999999938));
#846=LINE('',#845,#844);
#847=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-459.999999999938));
#848=VERTEX_POINT('',#847);
#849=EDGE_CURVE('E626',#840,#848,#846,.F.);
#850=ORIENTED_EDGE('',*,*,#849,.T.);
#851=DIRECTION('',(0.,0.,1.));
#852=VECTOR('',#851,1.);
#853=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-555.000000000066));
#854=LINE('',#853,#852);
#855=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-555.000000000066));
#856=VERTEX_POINT('',#855);
#857=EDGE_CURVE('E619',#848,#856,#854,.F.);
#858=ORIENTED_EDGE('',*,*,#857,.T.);
#859=CARTESIAN_POINT('',(0.,-29.5000000000344,-555.000000000066));
#860=DIRECTION('',(0.,-1.,0.));
#861=DIRECTION('',(0.,0.,-1.));
#862=AXIS2_PLACEMENT_3D('',#859,#860,#861);
#863=CIRCLE('',#862,10.0000000000006);
#864=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-555.000000000066));
#865=VERTEX_POINT('',#864);
#866=EDGE_CURVE('E602',#856,#865,#863,.T.);
#867=ORIENTED_EDGE('',*,*,#866,.T.);
#868=DIRECTION('',(0.,0.,-1.));
#869=VECTOR('',#868,1.);
#870=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-555.000000000066));
#871=LINE('',#870,#869);
#872=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-459.999999999938));
#873=VERTEX_POINT('',#872);
#874=EDGE_CURVE('E636',#865,#873,#871,.F.);
#875=ORIENTED_EDGE('',*,*,#874,.T.);
#876=DIRECTION('',(-1.,0.,0.));
#877=VECTOR('',#876,1.);
#878=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-459.999999999938));
#879=LINE('',#878,#877);
#880=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-459.999999999958));
#881=VERTEX_POINT('',#880);
#882=EDGE_CURVE('E1492',#873,#881,#879,.F.);
#883=ORIENTED_EDGE('',*,*,#882,.T.);
#884=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-449.999999999978));
#885=DIRECTION('',(0.,-1.,0.));
#886=DIRECTION('',(0.,0.,-1.));
#887=AXIS2_PLACEMENT_3D('',#884,#885,#886);
#888=CIRCLE('',#887,10.0000000000006);
#889=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-440.000000000018));
#890=VERTEX_POINT('',#889);
#891=EDGE_CURVE('E791',#881,#890,#888,.T.);
#892=ORIENTED_EDGE('',*,*,#891,.T.);
#893=DIRECTION('',(1.,0.,0.));
#894=VECTOR('',#893,1.);
#895=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-440.000000000018));
#896=LINE('',#895,#894);
#897=EDGE_CURVE('E1341',#890,#804,#896,.F.);
#898=ORIENTED_EDGE('',*,*,#897,.T.);
#899=EDGE_LOOP('',(#808,#817,#825,#833,#842,#850,#858,#867,#875,#883,#892,#898));
#900=FACE_BOUND('',#899,.T.);
#901=ADVANCED_FACE('F624',(#787,#798,#900),#776,.T.);
#902=CARTESIAN_POINT('',(0.,-30.000000000007,-579.999999999966));
#903=DIRECTION('',(0.,-1.,0.));
#904=DIRECTION('',(0.,0.,-1.));
#905=AXIS2_PLACEMENT_3D('',#902,#903,#904);
#906=CYLINDRICAL_SURFACE('',#905,2.49999999999991);
#907=CARTESIAN_POINT('',(0.,-30.000000000007,-579.999999999966));
#908=DIRECTION('',(0.,-1.,0.));
#909=DIRECTION('',(0.,0.,-1.));
#910=AXIS2_PLACEMENT_3D('',#907,#908,#909);
#911=CIRCLE('',#910,2.49999999999991);
#912=CARTESIAN_POINT('',(0.,-30.000000000007,-582.499999999966));
#913=VERTEX_POINT('',#912);
#914=EDGE_CURVE('E753',#913,#913,#911,.T.);
#915=ORIENTED_EDGE('',*,*,#914,.T.);
#916=EDGE_LOOP('',(#915));
#917=FACE_BOUND('',#916,.T.);
#918=ORIENTED_EDGE('',*,*,#477,.F.);
#919=EDGE_LOOP('',(#918));
#920=FACE_BOUND('',#919,.T.);
#921=ADVANCED_FACE('F2706',(#917,#920),#906,.F.);
#922=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-555.000000000066));
#923=DIRECTION('',(1.,0.,0.));
#924=DIRECTION('',(0.,0.,-1.));
#925=AXIS2_PLACEMENT_3D('',#922,#923,#924);
#926=PLANE('',#925);
#927=DIRECTION('',(0.,1.,0.));
#928=VECTOR('',#927,1.);
#929=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-459.999999999938));
#930=LINE('',#929,#928);
#931=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-459.999999999938));
#932=VERTEX_POINT('',#931);
#933=EDGE_CURVE('E1501',#932,#873,#930,.T.);
#934=ORIENTED_EDGE('',*,*,#933,.T.);
#935=ORIENTED_EDGE('',*,*,#874,.F.);
#936=DIRECTION('',(0.,-1.,0.));
#937=VECTOR('',#936,1.);
#938=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-555.000000000066));
#939=LINE('',#938,#937);
#940=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000251,-555.000000000066));
#941=VERTEX_POINT('',#940);
#942=EDGE_CURVE('E610',#865,#941,#939,.T.);
#943=ORIENTED_EDGE('',*,*,#942,.T.);
#944=DIRECTION('',(0.,0.,-1.));
#945=VECTOR('',#944,1.);
#946=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-594.999999999906));
#947=LINE('',#946,#945);
#948=EDGE_CURVE('E752',#932,#941,#947,.T.);
#949=ORIENTED_EDGE('',*,*,#948,.F.);
#950=EDGE_LOOP('',(#934,#935,#943,#949));
#951=FACE_BOUND('',#950,.T.);
#952=ADVANCED_FACE('F1672',(#951),#926,.F.);
#953=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-594.999999999906));
#954=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#955=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#956=AXIS2_PLACEMENT_3D('',#953,#954,#955);
#957=PLANE('',#956);
#958=DIRECTION('',(-0.707106781186545,-0.70710678118655,0.));
#959=VECTOR('',#958,1.);
#960=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-459.999999999938));
#961=LINE('',#960,#959);
#962=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-459.999999999938));
#963=VERTEX_POINT('',#962);
#964=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-459.999999999938));
#965=VERTEX_POINT('',#964);
#966=EDGE_CURVE('E1477',#963,#965,#961,.T.);
#967=ORIENTED_EDGE('',*,*,#966,.T.);
#968=DIRECTION('',(0.,0.,-1.));
#969=VECTOR('',#968,1.);
#970=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-594.999999999906));
#971=LINE('',#970,#969);
#972=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-594.999999999906));
#973=VERTEX_POINT('',#972);
#974=EDGE_CURVE('E1512',#973,#965,#971,.F.);
#975=ORIENTED_EDGE('',*,*,#974,.F.);
#976=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#977=VECTOR('',#976,1.);
#978=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-594.999999999906));
#979=LINE('',#978,#977);
#980=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-594.999999999906));
#981=VERTEX_POINT('',#980);
#982=EDGE_CURVE('E1499',#981,#973,#979,.T.);
#983=ORIENTED_EDGE('',*,*,#982,.F.);
#984=DIRECTION('',(0.,0.,1.));
#985=VECTOR('',#984,1.);
#986=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-594.999999999906));
#987=LINE('',#986,#985);
#988=EDGE_CURVE('E1262',#981,#963,#987,.T.);
#989=ORIENTED_EDGE('',*,*,#988,.T.);
#990=EDGE_LOOP('',(#967,#975,#983,#989));
#991=FACE_BOUND('',#990,.T.);
#992=ADVANCED_FACE('F3115',(#991),#957,.F.);
#993=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-459.999999999938));
#994=DIRECTION('',(0.,0.,-1.));
#995=DIRECTION('',(-1.,0.,0.));
#996=AXIS2_PLACEMENT_3D('',#993,#994,#995);
#997=PLANE('',#996);
#998=ORIENTED_EDGE('',*,*,#966,.F.);
#999=DIRECTION('',(1.,0.,0.));
#1000=VECTOR('',#999,1.);
#1001=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-459.999999999938));
#1002=LINE('',#1001,#1000);
#1003=CARTESIAN_POINT('',(44.9999999999978,-33.999999999991,-459.999999999958));
#1004=VERTEX_POINT('',#1003);
#1005=EDGE_CURVE('E748',#963,#1004,#1002,.T.);
#1006=ORIENTED_EDGE('',*,*,#1005,.T.);
#1007=DIRECTION('',(0.,-1.,0.));
#1008=VECTOR('',#1007,1.);
#1009=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-459.999999999979));
#1010=LINE('',#1009,#1008);
#1011=EDGE_CURVE('E794',#1004,#881,#1010,.F.);
#1012=ORIENTED_EDGE('',*,*,#1011,.T.);
#1013=ORIENTED_EDGE('',*,*,#882,.F.);
#1014=ORIENTED_EDGE('',*,*,#933,.F.);
#1015=DIRECTION('',(1.,0.,0.));
#1016=VECTOR('',#1015,1.);
#1017=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-459.999999999938));
#1018=LINE('',#1017,#1016);
#1019=EDGE_CURVE('E1269',#965,#932,#1018,.F.);
#1020=ORIENTED_EDGE('',*,*,#1019,.F.);
#1021=EDGE_LOOP('',(#998,#1006,#1012,#1013,#1014,#1020));
#1022=FACE_BOUND('',#1021,.T.);
#1023=ADVANCED_FACE('F1676',(#1022),#997,.F.);
#1024=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-594.999999999906));
#1025=DIRECTION('',(0.707106781186498,0.707106781186598,0.));
#1026=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#1027=AXIS2_PLACEMENT_3D('',#1024,#1025,#1026);
#1028=PLANE('',#1027);
#1029=DIRECTION('',(0.,0.,1.));
#1030=VECTOR('',#1029,1.);
#1031=CARTESIAN_POINT('',(51.4999999999972,-33.999999999991,-594.999999999906));
#1032=LINE('',#1031,#1030);
#1033=CARTESIAN_POINT('',(51.4999999999972,-33.999999999991,-457.999999999946));
#1034=VERTEX_POINT('',#1033);
#1035=CARTESIAN_POINT('',(51.4999999999908,-33.9999999999974,-594.999999999906));
#1036=VERTEX_POINT('',#1035);
#1037=EDGE_CURVE('E1257',#1034,#1036,#1032,.F.);
#1038=ORIENTED_EDGE('',*,*,#1037,.T.);
#1039=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#1040=VECTOR('',#1039,1.);
#1041=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-594.999999999906));
#1042=LINE('',#1041,#1040);
#1043=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-594.999999999906));
#1044=VERTEX_POINT('',#1043);
#1045=EDGE_CURVE('E813',#1044,#1036,#1042,.T.);
#1046=ORIENTED_EDGE('',*,*,#1045,.F.);
#1047=DIRECTION('',(0.,0.,-1.));
#1048=VECTOR('',#1047,1.);
#1049=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-594.999999999906));
#1050=LINE('',#1049,#1048);
#1051=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-457.999999999946));
#1052=VERTEX_POINT('',#1051);
#1053=EDGE_CURVE('E1485',#1052,#1044,#1050,.T.);
#1054=ORIENTED_EDGE('',*,*,#1053,.F.);
#1055=DIRECTION('',(0.707106781177556,-0.707106781195539,0.));
#1056=VECTOR('',#1055,1.);
#1057=CARTESIAN_POINT('',(51.4999999999972,-33.999999999991,-457.999999999946));
#1058=LINE('',#1057,#1056);
#1059=EDGE_CURVE('E783',#1034,#1052,#1058,.T.);
#1060=ORIENTED_EDGE('',*,*,#1059,.F.);
#1061=EDGE_LOOP('',(#1038,#1046,#1054,#1060));
#1062=FACE_BOUND('',#1061,.T.);
#1063=ADVANCED_FACE('F3131',(#1062),#1028,.F.);
#1064=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-571.999999999998));
#1065=DIRECTION('',(0.,1.,0.));
#1066=DIRECTION('',(0.,0.,1.));
#1067=AXIS2_PLACEMENT_3D('',#1064,#1065,#1066);
#1068=CYLINDRICAL_SURFACE('',#1067,10.0000000000006);
#1069=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-571.999999999998));
#1070=DIRECTION('',(0.,1.,0.));
#1071=DIRECTION('',(0.,0.,1.));
#1072=AXIS2_PLACEMENT_3D('',#1069,#1070,#1071);
#1073=CIRCLE('',#1072,10.0000000000006);
#1074=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-561.999999999997));
#1075=VERTEX_POINT('',#1074);
#1076=EDGE_CURVE('E740',#1075,#1075,#1073,.F.);
#1077=ORIENTED_EDGE('',*,*,#1076,.F.);
#1078=EDGE_LOOP('',(#1077));
#1079=FACE_BOUND('',#1078,.T.);
#1080=ORIENTED_EDGE('',*,*,#497,.F.);
#1081=EDGE_LOOP('',(#1080));
#1082=FACE_BOUND('',#1081,.T.);
#1083=ADVANCED_FACE('F3139',(#1079,#1082),#1068,.F.);
#1084=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-571.999999999998));
#1085=DIRECTION('',(0.,1.,0.));
#1086=DIRECTION('',(0.,0.,1.));
#1087=AXIS2_PLACEMENT_3D('',#1084,#1085,#1086);
#1088=CYLINDRICAL_SURFACE('',#1087,10.0000000000006);
#1089=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-571.999999999998));
#1090=DIRECTION('',(0.,1.,0.));
#1091=DIRECTION('',(0.,0.,1.));
#1092=AXIS2_PLACEMENT_3D('',#1089,#1090,#1091);
#1093=CIRCLE('',#1092,10.0000000000006);
#1094=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-561.999999999997));
#1095=VERTEX_POINT('',#1094);
#1096=EDGE_CURVE('E735',#1095,#1095,#1093,.F.);
#1097=ORIENTED_EDGE('',*,*,#1096,.F.);
#1098=EDGE_LOOP('',(#1097));
#1099=FACE_BOUND('',#1098,.T.);
#1100=ORIENTED_EDGE('',*,*,#517,.F.);
#1101=EDGE_LOOP('',(#1100));
#1102=FACE_BOUND('',#1101,.T.);
#1103=ADVANCED_FACE('F3148',(#1099,#1102),#1088,.F.);
#1104=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-594.999999999906));
#1105=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#1106=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#1107=AXIS2_PLACEMENT_3D('',#1104,#1105,#1106);
#1108=PLANE('',#1107);
#1109=DIRECTION('',(0.,0.,-1.));
#1110=VECTOR('',#1109,1.);
#1111=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-594.999999999906));
#1112=LINE('',#1111,#1110);
#1113=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-594.999999999906));
#1114=VERTEX_POINT('',#1113);
#1115=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-457.999999999946));
#1116=VERTEX_POINT('',#1115);
#1117=EDGE_CURVE('E738',#1114,#1116,#1112,.F.);
#1118=ORIENTED_EDGE('',*,*,#1117,.F.);
#1119=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#1120=VECTOR('',#1119,1.);
#1121=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-594.999999999906));
#1122=LINE('',#1121,#1120);
#1123=CARTESIAN_POINT('',(-51.4999999999909,-33.9999999999973,-594.999999999906));
#1124=VERTEX_POINT('',#1123);
#1125=EDGE_CURVE('E614',#1124,#1114,#1122,.T.);
#1126=ORIENTED_EDGE('',*,*,#1125,.F.);
#1127=DIRECTION('',(0.,0.,1.));
#1128=VECTOR('',#1127,1.);
#1129=CARTESIAN_POINT('',(-51.4999999999972,-33.999999999991,-594.999999999906));
#1130=LINE('',#1129,#1128);
#1131=CARTESIAN_POINT('',(-51.4999999999972,-33.999999999991,-457.999999999946));
#1132=VERTEX_POINT('',#1131);
#1133=EDGE_CURVE('E729',#1124,#1132,#1130,.T.);
#1134=ORIENTED_EDGE('',*,*,#1133,.T.);
#1135=DIRECTION('',(0.707106781177561,0.707106781195534,0.));
#1136=VECTOR('',#1135,1.);
#1137=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-457.999999999946));
#1138=LINE('',#1137,#1136);
#1139=EDGE_CURVE('E1322',#1116,#1132,#1138,.T.);
#1140=ORIENTED_EDGE('',*,*,#1139,.F.);
#1141=EDGE_LOOP('',(#1118,#1126,#1134,#1140));
#1142=FACE_BOUND('',#1141,.T.);
#1143=ADVANCED_FACE('F1797',(#1142),#1108,.F.);
#1144=CARTESIAN_POINT('',(0.,-29.5000000000344,-555.000000000066));
#1145=DIRECTION('',(0.,-1.,0.));
#1146=DIRECTION('',(0.,0.,-1.));
#1147=AXIS2_PLACEMENT_3D('',#1144,#1145,#1146);
#1148=CYLINDRICAL_SURFACE('',#1147,10.0000000000006);
#1149=DIRECTION('',(0.,1.,0.));
#1150=VECTOR('',#1149,1.);
#1151=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-555.000000000066));
#1152=LINE('',#1151,#1150);
#1153=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-555.000000000066));
#1154=VERTEX_POINT('',#1153);
#1155=EDGE_CURVE('E606',#856,#1154,#1152,.F.);
#1156=ORIENTED_EDGE('',*,*,#1155,.T.);
#1157=CARTESIAN_POINT('',(0.,-35.0000000000124,-555.000000000066));
#1158=DIRECTION('',(0.,-1.,0.));
#1159=DIRECTION('',(0.,0.,-1.));
#1160=AXIS2_PLACEMENT_3D('',#1157,#1158,#1159);
#1161=CIRCLE('',#1160,10.0000000000006);
#1162=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-561.000000000054));
#1163=VERTEX_POINT('',#1162);
#1164=EDGE_CURVE('E727',#1163,#1154,#1161,.F.);
#1165=ORIENTED_EDGE('',*,*,#1164,.F.);
#1166=DIRECTION('',(0.,1.,0.));
#1167=VECTOR('',#1166,1.);
#1168=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-561.000000000042));
#1169=LINE('',#1168,#1167);
#1170=CARTESIAN_POINT('',(-8.00000000000102,-30.000000000007,-561.000000000054));
#1171=VERTEX_POINT('',#1170);
#1172=EDGE_CURVE('E1274',#1163,#1171,#1169,.T.);
#1173=ORIENTED_EDGE('',*,*,#1172,.T.);
#1174=CARTESIAN_POINT('',(0.,-30.000000000007,-555.000000000066));
#1175=DIRECTION('',(0.,-1.,0.));
#1176=DIRECTION('',(0.,0.,-1.));
#1177=AXIS2_PLACEMENT_3D('',#1174,#1175,#1176);
#1178=CIRCLE('',#1177,10.0000000000006);
#1179=CARTESIAN_POINT('',(8.00000000000102,-30.000000000007,-561.000000000054));
#1180=VERTEX_POINT('',#1179);
#1181=EDGE_CURVE('E757',#1171,#1180,#1178,.T.);
#1182=ORIENTED_EDGE('',*,*,#1181,.T.);
#1183=DIRECTION('',(0.,1.,0.));
#1184=VECTOR('',#1183,1.);
#1185=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-561.000000000042));
#1186=LINE('',#1185,#1184);
#1187=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000251,-561.000000000054));
#1188=VERTEX_POINT('',#1187);
#1189=EDGE_CURVE('E1509',#1180,#1188,#1186,.F.);
#1190=ORIENTED_EDGE('',*,*,#1189,.T.);
#1191=CARTESIAN_POINT('',(0.,-35.0000000000378,-555.000000000066));
#1192=DIRECTION('',(0.,-1.,0.));
#1193=DIRECTION('',(0.,0.,-1.));
#1194=AXIS2_PLACEMENT_3D('',#1191,#1192,#1193);
#1195=CIRCLE('',#1194,10.0000000000006);
#1196=EDGE_CURVE('E749',#941,#1188,#1195,.F.);
#1197=ORIENTED_EDGE('',*,*,#1196,.F.);
#1198=ORIENTED_EDGE('',*,*,#942,.F.);
#1199=ORIENTED_EDGE('',*,*,#866,.F.);
#1200=EDGE_LOOP('',(#1156,#1165,#1173,#1182,#1190,#1197,#1198,#1199));
#1201=FACE_BOUND('',#1200,.T.);
#1202=ADVANCED_FACE('F604',(#1201),#1148,.F.);
#1203=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-555.000000000066));
#1204=DIRECTION('',(-1.,0.,0.));
#1205=DIRECTION('',(0.,0.,1.));
#1206=AXIS2_PLACEMENT_3D('',#1203,#1204,#1205);
#1207=PLANE('',#1206);
#1208=DIRECTION('',(0.,1.,0.));
#1209=VECTOR('',#1208,1.);
#1210=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-459.999999999938));
#1211=LINE('',#1210,#1209);
#1212=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-459.999999999938));
#1213=VERTEX_POINT('',#1212);
#1214=EDGE_CURVE('E628',#848,#1213,#1211,.F.);
#1215=ORIENTED_EDGE('',*,*,#1214,.T.);
#1216=DIRECTION('',(0.,0.,-1.));
#1217=VECTOR('',#1216,1.);
#1218=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-594.999999999906));
#1219=LINE('',#1218,#1217);
#1220=EDGE_CURVE('E621',#1154,#1213,#1219,.F.);
#1221=ORIENTED_EDGE('',*,*,#1220,.F.);
#1222=ORIENTED_EDGE('',*,*,#1155,.F.);
#1223=ORIENTED_EDGE('',*,*,#857,.F.);
#1224=EDGE_LOOP('',(#1215,#1221,#1222,#1223));
#1225=FACE_BOUND('',#1224,.T.);
#1226=ADVANCED_FACE('F618',(#1225),#1207,.F.);
#1227=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-459.999999999938));
#1228=DIRECTION('',(0.,0.,-1.));
#1229=DIRECTION('',(-1.,0.,0.));
#1230=AXIS2_PLACEMENT_3D('',#1227,#1228,#1229);
#1231=PLANE('',#1230);
#1232=DIRECTION('',(-0.707106781186548,0.707106781186548,0.));
#1233=VECTOR('',#1232,1.);
#1234=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-459.999999999938));
#1235=LINE('',#1234,#1233);
#1236=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-459.999999999938));
#1237=VERTEX_POINT('',#1236);
#1238=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-459.999999999938));
#1239=VERTEX_POINT('',#1238);
#1240=EDGE_CURVE('E1448',#1237,#1239,#1235,.F.);
#1241=ORIENTED_EDGE('',*,*,#1240,.T.);
#1242=DIRECTION('',(1.,0.,0.));
#1243=VECTOR('',#1242,1.);
#1244=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-459.999999999938));
#1245=LINE('',#1244,#1243);
#1246=EDGE_CURVE('E1239',#1213,#1239,#1245,.F.);
#1247=ORIENTED_EDGE('',*,*,#1246,.F.);
#1248=ORIENTED_EDGE('',*,*,#1214,.F.);
#1249=ORIENTED_EDGE('',*,*,#849,.F.);
#1250=DIRECTION('',(0.,-1.,0.));
#1251=VECTOR('',#1250,1.);
#1252=CARTESIAN_POINT('',(-44.9999999999978,-29.5000000000344,-459.999999999979));
#1253=LINE('',#1252,#1251);
#1254=CARTESIAN_POINT('',(-44.9999999999978,-33.999999999991,-459.999999999958));
#1255=VERTEX_POINT('',#1254);
#1256=EDGE_CURVE('E762',#840,#1255,#1253,.T.);
#1257=ORIENTED_EDGE('',*,*,#1256,.T.);
#1258=DIRECTION('',(1.,0.,0.));
#1259=VECTOR('',#1258,1.);
#1260=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-459.999999999938));
#1261=LINE('',#1260,#1259);
#1262=EDGE_CURVE('E733',#1255,#1237,#1261,.T.);
#1263=ORIENTED_EDGE('',*,*,#1262,.T.);
#1264=EDGE_LOOP('',(#1241,#1247,#1248,#1249,#1257,#1263));
#1265=FACE_BOUND('',#1264,.T.);
#1266=ADVANCED_FACE('F1790',(#1265),#1231,.F.);
#1267=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-594.999999999906));
#1268=DIRECTION('',(0.707106781186548,0.707106781186548,0.));
#1269=DIRECTION('',(-0.707106781186548,0.707106781186548,0.));
#1270=AXIS2_PLACEMENT_3D('',#1267,#1268,#1269);
#1271=PLANE('',#1270);
#1272=ORIENTED_EDGE('',*,*,#1240,.F.);
#1273=DIRECTION('',(0.,0.,1.));
#1274=VECTOR('',#1273,1.);
#1275=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-594.999999999906));
#1276=LINE('',#1275,#1274);
#1277=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-594.999999999906));
#1278=VERTEX_POINT('',#1277);
#1279=EDGE_CURVE('E1244',#1237,#1278,#1276,.F.);
#1280=ORIENTED_EDGE('',*,*,#1279,.T.);
#1281=DIRECTION('',(-0.707106781186548,0.707106781186548,0.));
#1282=VECTOR('',#1281,1.);
#1283=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-594.999999999906));
#1284=LINE('',#1283,#1282);
#1285=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-594.999999999906));
#1286=VERTEX_POINT('',#1285);
#1287=EDGE_CURVE('E1447',#1286,#1278,#1284,.T.);
#1288=ORIENTED_EDGE('',*,*,#1287,.F.);
#1289=DIRECTION('',(0.,0.,-1.));
#1290=VECTOR('',#1289,1.);
#1291=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-594.999999999906));
#1292=LINE('',#1291,#1290);
#1293=EDGE_CURVE('E1235',#1239,#1286,#1292,.T.);
#1294=ORIENTED_EDGE('',*,*,#1293,.F.);
#1295=EDGE_LOOP('',(#1272,#1280,#1288,#1294));
#1296=FACE_BOUND('',#1295,.T.);
#1297=ADVANCED_FACE('F1791',(#1296),#1271,.F.);
#1298=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-449.999999999978));
#1299=DIRECTION('',(1.,0.,0.));
#1300=DIRECTION('',(0.,0.,-1.));
#1301=AXIS2_PLACEMENT_3D('',#1298,#1299,#1300);
#1302=PLANE('',#1301);
#1303=DIRECTION('',(0.,-1.,0.));
#1304=VECTOR('',#1303,1.);
#1305=CARTESIAN_POINT('',(-8.00000000001238,-29.500000000009,-298.666666666751));
#1306=LINE('',#1305,#1304);
#1307=CARTESIAN_POINT('',(-8.0000000000067,-35.0000000000124,-298.666666666758));
#1308=VERTEX_POINT('',#1307);
#1309=EDGE_CURVE('E805',#537,#1308,#1306,.T.);
#1310=ORIENTED_EDGE('',*,*,#1309,.T.);
#1311=DIRECTION('',(0.,0.,-1.));
#1312=VECTOR('',#1311,1.);
#1313=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-594.999999999906));
#1314=LINE('',#1313,#1312);
#1315=CARTESIAN_POINT('',(-8.0000000000067,-35.0000000000124,-335.670000000018));
#1316=VERTEX_POINT('',#1315);
#1317=EDGE_CURVE('E722',#1316,#1308,#1314,.F.);
#1318=ORIENTED_EDGE('',*,*,#1317,.F.);
#1319=DIRECTION('',(0.,-1.,0.));
#1320=VECTOR('',#1319,1.);
#1321=CARTESIAN_POINT('',(-8.00000000001237,-29.5000000000344,-335.670000000025));
#1322=LINE('',#1321,#1320);
#1323=EDGE_CURVE('E802',#1316,#535,#1322,.F.);
#1324=ORIENTED_EDGE('',*,*,#1323,.T.);
#1325=ORIENTED_EDGE('',*,*,#538,.T.);
#1326=EDGE_LOOP('',(#1310,#1318,#1324,#1325));
#1327=FACE_BOUND('',#1326,.T.);
#1328=ADVANCED_FACE('F1746',(#1327),#1302,.T.);
#1329=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-555.000000000066));
#1330=DIRECTION('',(-1.,0.,0.));
#1331=DIRECTION('',(0.,0.,1.));
#1332=AXIS2_PLACEMENT_3D('',#1329,#1330,#1331);
#1333=PLANE('',#1332);
#1334=DIRECTION('',(0.,1.,0.));
#1335=VECTOR('',#1334,1.);
#1336=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-440.000000000018));
#1337=LINE('',#1336,#1335);
#1338=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-440.000000000018));
#1339=VERTEX_POINT('',#1338);
#1340=EDGE_CURVE('E1313',#1339,#823,#1337,.T.);
#1341=ORIENTED_EDGE('',*,*,#1340,.T.);
#1342=ORIENTED_EDGE('',*,*,#824,.F.);
#1343=DIRECTION('',(0.,-1.,0.));
#1344=VECTOR('',#1343,1.);
#1345=CARTESIAN_POINT('',(-10.0000000000006,-29.5000000000344,-341.67000000001));
#1346=LINE('',#1345,#1344);
#1347=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-341.67000000001));
#1348=VERTEX_POINT('',#1347);
#1349=EDGE_CURVE('E1431',#815,#1348,#1346,.T.);
#1350=ORIENTED_EDGE('',*,*,#1349,.T.);
#1351=DIRECTION('',(0.,0.,-1.));
#1352=VECTOR('',#1351,1.);
#1353=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-594.999999999906));
#1354=LINE('',#1353,#1352);
#1355=EDGE_CURVE('E1225',#1339,#1348,#1354,.F.);
#1356=ORIENTED_EDGE('',*,*,#1355,.F.);
#1357=EDGE_LOOP('',(#1341,#1342,#1350,#1356));
#1358=FACE_BOUND('',#1357,.T.);
#1359=ADVANCED_FACE('F1752',(#1358),#1333,.F.);
#1360=CARTESIAN_POINT('',(0.,-29.500000000009,-292.666666666766));
#1361=DIRECTION('',(0.,-1.,0.));
#1362=DIRECTION('',(0.,0.,-1.));
#1363=AXIS2_PLACEMENT_3D('',#1360,#1361,#1362);
#1364=CYLINDRICAL_SURFACE('',#1363,10.0000000000006);
#1365=ORIENTED_EDGE('',*,*,#562,.F.);
#1366=DIRECTION('',(0.,1.,0.));
#1367=VECTOR('',#1366,1.);
#1368=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-298.666666666742));
#1369=LINE('',#1368,#1367);
#1370=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-298.666666666754));
#1371=VERTEX_POINT('',#1370);
#1372=EDGE_CURVE('E804',#1371,#554,#1369,.T.);
#1373=ORIENTED_EDGE('',*,*,#1372,.F.);
#1374=CARTESIAN_POINT('',(0.,-35.0000000000124,-292.666666666766));
#1375=DIRECTION('',(0.,-1.,0.));
#1376=DIRECTION('',(0.,0.,-1.));
#1377=AXIS2_PLACEMENT_3D('',#1374,#1375,#1376);
#1378=CIRCLE('',#1377,10.0000000000006);
#1379=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-292.666666666766));
#1380=VERTEX_POINT('',#1379);
#1381=EDGE_CURVE('E712',#1380,#1371,#1378,.F.);
#1382=ORIENTED_EDGE('',*,*,#1381,.F.);
#1383=DIRECTION('',(0.,1.,0.));
#1384=VECTOR('',#1383,1.);
#1385=CARTESIAN_POINT('',(10.0000000000006,-29.500000000009,-292.666666666766));
#1386=LINE('',#1385,#1384);
#1387=CARTESIAN_POINT('',(10.0000000000006,-29.500000000009,-292.666666666766));
#1388=VERTEX_POINT('',#1387);
#1389=EDGE_CURVE('E717',#1380,#1388,#1386,.T.);
#1390=ORIENTED_EDGE('',*,*,#1389,.T.);
#1391=CARTESIAN_POINT('',(0.,-29.500000000009,-292.666666666766));
#1392=DIRECTION('',(0.,-1.,0.));
#1393=DIRECTION('',(0.,0.,-1.));
#1394=AXIS2_PLACEMENT_3D('',#1391,#1392,#1393);
#1395=CIRCLE('',#1394,10.0000000000006);
#1396=CARTESIAN_POINT('',(-10.0000000000006,-29.500000000009,-292.666666666766));
#1397=VERTEX_POINT('',#1396);
#1398=EDGE_CURVE('E715',#1397,#1388,#1395,.T.);
#1399=ORIENTED_EDGE('',*,*,#1398,.F.);
#1400=DIRECTION('',(0.,1.,0.));
#1401=VECTOR('',#1400,1.);
#1402=CARTESIAN_POINT('',(-10.0000000000006,-29.500000000009,-292.666666666766));
#1403=LINE('',#1402,#1401);
#1404=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-292.666666666766));
#1405=VERTEX_POINT('',#1404);
#1406=EDGE_CURVE('E1228',#1397,#1405,#1403,.F.);
#1407=ORIENTED_EDGE('',*,*,#1406,.T.);
#1408=CARTESIAN_POINT('',(0.,-35.0000000000124,-292.666666666766));
#1409=DIRECTION('',(0.,-1.,0.));
#1410=DIRECTION('',(0.,0.,-1.));
#1411=AXIS2_PLACEMENT_3D('',#1408,#1409,#1410);
#1412=CIRCLE('',#1411,10.0000000000006);
#1413=EDGE_CURVE('E719',#1308,#1405,#1412,.F.);
#1414=ORIENTED_EDGE('',*,*,#1413,.F.);
#1415=ORIENTED_EDGE('',*,*,#1309,.F.);
#1416=EDGE_LOOP('',(#1365,#1373,#1382,#1390,#1399,#1407,#1414,#1415));
#1417=FACE_BOUND('',#1416,.T.);
#1418=ADVANCED_FACE('F3204',(#1417),#1364,.F.);
#1419=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-449.999999999978));
#1420=DIRECTION('',(-1.,0.,0.));
#1421=DIRECTION('',(0.,0.,1.));
#1422=AXIS2_PLACEMENT_3D('',#1419,#1420,#1421);
#1423=PLANE('',#1422);
#1424=ORIENTED_EDGE('',*,*,#1372,.T.);
#1425=ORIENTED_EDGE('',*,*,#555,.T.);
#1426=DIRECTION('',(0.,-1.,0.));
#1427=VECTOR('',#1426,1.);
#1428=CARTESIAN_POINT('',(8.00000000001238,-29.5000000000344,-335.670000000025));
#1429=LINE('',#1428,#1427);
#1430=CARTESIAN_POINT('',(8.0000000000067,-35.0000000000124,-335.670000000018));
#1431=VERTEX_POINT('',#1430);
#1432=EDGE_CURVE('E798',#546,#1431,#1429,.T.);
#1433=ORIENTED_EDGE('',*,*,#1432,.T.);
#1434=DIRECTION('',(0.,0.,-1.));
#1435=VECTOR('',#1434,1.);
#1436=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-594.999999999906));
#1437=LINE('',#1436,#1435);
#1438=EDGE_CURVE('E711',#1371,#1431,#1437,.T.);
#1439=ORIENTED_EDGE('',*,*,#1438,.F.);
#1440=EDGE_LOOP('',(#1424,#1425,#1433,#1439));
#1441=FACE_BOUND('',#1440,.T.);
#1442=ADVANCED_FACE('F3209',(#1441),#1423,.T.);
#1443=CARTESIAN_POINT('',(0.,-29.5000000000344,-341.67000000001));
#1444=DIRECTION('',(0.,-1.,0.));
#1445=DIRECTION('',(0.,0.,-1.));
#1446=AXIS2_PLACEMENT_3D('',#1443,#1444,#1445);
#1447=CYLINDRICAL_SURFACE('',#1446,10.0000000000006);
#1448=DIRECTION('',(0.,1.,0.));
#1449=VECTOR('',#1448,1.);
#1450=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-341.67000000001));
#1451=LINE('',#1450,#1449);
#1452=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-341.67000000001));
#1453=VERTEX_POINT('',#1452);
#1454=EDGE_CURVE('E797',#806,#1453,#1451,.F.);
#1455=ORIENTED_EDGE('',*,*,#1454,.T.);
#1456=CARTESIAN_POINT('',(0.,-35.0000000000124,-341.67000000001));
#1457=DIRECTION('',(0.,-1.,0.));
#1458=DIRECTION('',(0.,0.,-1.));
#1459=AXIS2_PLACEMENT_3D('',#1456,#1457,#1458);
#1460=CIRCLE('',#1459,10.0000000000006);
#1461=EDGE_CURVE('E708',#1431,#1453,#1460,.F.);
#1462=ORIENTED_EDGE('',*,*,#1461,.F.);
#1463=ORIENTED_EDGE('',*,*,#1432,.F.);
#1464=ORIENTED_EDGE('',*,*,#547,.F.);
#1465=ORIENTED_EDGE('',*,*,#1323,.F.);
#1466=CARTESIAN_POINT('',(0.,-35.0000000000124,-341.67000000001));
#1467=DIRECTION('',(0.,-1.,0.));
#1468=DIRECTION('',(0.,0.,-1.));
#1469=AXIS2_PLACEMENT_3D('',#1466,#1467,#1468);
#1470=CIRCLE('',#1469,10.0000000000006);
#1471=EDGE_CURVE('E723',#1348,#1316,#1470,.F.);
#1472=ORIENTED_EDGE('',*,*,#1471,.F.);
#1473=ORIENTED_EDGE('',*,*,#1349,.F.);
#1474=ORIENTED_EDGE('',*,*,#816,.F.);
#1475=EDGE_LOOP('',(#1455,#1462,#1463,#1464,#1465,#1472,#1473,#1474));
#1476=FACE_BOUND('',#1475,.T.);
#1477=ADVANCED_FACE('F1729',(#1476),#1447,.F.);
#1478=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-555.000000000066));
#1479=DIRECTION('',(1.,0.,0.));
#1480=DIRECTION('',(0.,0.,-1.));
#1481=AXIS2_PLACEMENT_3D('',#1478,#1479,#1480);
#1482=PLANE('',#1481);
#1483=DIRECTION('',(0.,1.,0.));
#1484=VECTOR('',#1483,1.);
#1485=CARTESIAN_POINT('',(10.0000000000006,-29.5000000000344,-440.000000000018));
#1486=LINE('',#1485,#1484);
#1487=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-440.000000000018));
#1488=VERTEX_POINT('',#1487);
#1489=EDGE_CURVE('E1338',#804,#1488,#1486,.F.);
#1490=ORIENTED_EDGE('',*,*,#1489,.T.);
#1491=DIRECTION('',(0.,0.,-1.));
#1492=VECTOR('',#1491,1.);
#1493=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-594.999999999906));
#1494=LINE('',#1493,#1492);
#1495=EDGE_CURVE('E710',#1453,#1488,#1494,.T.);
#1496=ORIENTED_EDGE('',*,*,#1495,.F.);
#1497=ORIENTED_EDGE('',*,*,#1454,.F.);
#1498=ORIENTED_EDGE('',*,*,#807,.F.);
#1499=EDGE_LOOP('',(#1490,#1496,#1497,#1498));
#1500=FACE_BOUND('',#1499,.T.);
#1501=ADVANCED_FACE('F1733',(#1500),#1482,.F.);
#1502=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-449.999999999978));
#1503=DIRECTION('',(0.,-1.,0.));
#1504=DIRECTION('',(0.,0.,-1.));
#1505=AXIS2_PLACEMENT_3D('',#1502,#1503,#1504);
#1506=CYLINDRICAL_SURFACE('',#1505,10.0000000000006);
#1507=ORIENTED_EDGE('',*,*,#891,.F.);
#1508=ORIENTED_EDGE('',*,*,#1011,.F.);
#1509=CARTESIAN_POINT('',(44.9999999999978,-33.999999999991,-449.999999999978));
#1510=DIRECTION('',(0.,-1.,0.));
#1511=DIRECTION('',(0.,0.,-1.));
#1512=AXIS2_PLACEMENT_3D('',#1509,#1510,#1511);
#1513=CIRCLE('',#1512,10.0000000000006);
#1514=CARTESIAN_POINT('',(51.0000000000203,-33.999999999991,-457.999999999946));
#1515=VERTEX_POINT('',#1514);
#1516=EDGE_CURVE('E744',#1004,#1515,#1513,.T.);
#1517=ORIENTED_EDGE('',*,*,#1516,.T.);
#1518=DIRECTION('',(0.,1.,0.));
#1519=VECTOR('',#1518,1.);
#1520=CARTESIAN_POINT('',(50.9999999999992,-35.0000000000124,-457.999999999946));
#1521=LINE('',#1520,#1519);
#1522=CARTESIAN_POINT('',(51.0000000000203,-30.000000000007,-457.999999999946));
#1523=VERTEX_POINT('',#1522);
#1524=EDGE_CURVE('E1478',#1523,#1515,#1521,.F.);
#1525=ORIENTED_EDGE('',*,*,#1524,.F.);
#1526=CARTESIAN_POINT('',(44.9999999999978,-30.000000000007,-449.999999999978));
#1527=DIRECTION('',(0.,-1.,0.));
#1528=DIRECTION('',(0.,0.,-1.));
#1529=AXIS2_PLACEMENT_3D('',#1526,#1527,#1528);
#1530=CIRCLE('',#1529,10.0000000000006);
#1531=CARTESIAN_POINT('',(51.0000000000204,-30.000000000007,-442.00000000001));
#1532=VERTEX_POINT('',#1531);
#1533=EDGE_CURVE('E788',#1532,#1523,#1530,.F.);
#1534=ORIENTED_EDGE('',*,*,#1533,.F.);
#1535=DIRECTION('',(0.,1.,0.));
#1536=VECTOR('',#1535,1.);
#1537=CARTESIAN_POINT('',(50.9999999999992,-35.0000000000124,-442.00000000001));
#1538=LINE('',#1537,#1536);
#1539=CARTESIAN_POINT('',(51.0000000000204,-33.999999999991,-442.00000000001));
#1540=VERTEX_POINT('',#1539);
#1541=EDGE_CURVE('E1332',#1540,#1532,#1538,.T.);
#1542=ORIENTED_EDGE('',*,*,#1541,.F.);
#1543=CARTESIAN_POINT('',(44.9999999999978,-33.999999999991,-449.999999999978));
#1544=DIRECTION('',(0.,-1.,0.));
#1545=DIRECTION('',(0.,0.,-1.));
#1546=AXIS2_PLACEMENT_3D('',#1543,#1544,#1545);
#1547=CIRCLE('',#1546,10.0000000000006);
#1548=CARTESIAN_POINT('',(44.9999999999978,-33.999999999991,-440.000000000018));
#1549=VERTEX_POINT('',#1548);
#1550=EDGE_CURVE('E703',#1540,#1549,#1547,.T.);
#1551=ORIENTED_EDGE('',*,*,#1550,.T.);
#1552=DIRECTION('',(0.,1.,0.));
#1553=VECTOR('',#1552,1.);
#1554=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-440.000000000018));
#1555=LINE('',#1554,#1553);
#1556=EDGE_CURVE('E793',#1549,#890,#1555,.T.);
#1557=ORIENTED_EDGE('',*,*,#1556,.T.);
#1558=EDGE_LOOP('',(#1507,#1508,#1517,#1525,#1534,#1542,#1551,#1557));
#1559=FACE_BOUND('',#1558,.T.);
#1560=ADVANCED_FACE('F1680',(#1559),#1506,.F.);
#1561=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-440.000000000018));
#1562=DIRECTION('',(0.,0.,1.));
#1563=DIRECTION('',(1.,0.,0.));
#1564=AXIS2_PLACEMENT_3D('',#1561,#1562,#1563);
#1565=PLANE('',#1564);
#1566=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#1567=VECTOR('',#1566,1.);
#1568=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-440.000000000018));
#1569=LINE('',#1568,#1567);
#1570=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-440.000000000018));
#1571=VERTEX_POINT('',#1570);
#1572=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-440.000000000018));
#1573=VERTEX_POINT('',#1572);
#1574=EDGE_CURVE('E1337',#1571,#1573,#1569,.T.);
#1575=ORIENTED_EDGE('',*,*,#1574,.T.);
#1576=DIRECTION('',(1.,0.,0.));
#1577=VECTOR('',#1576,1.);
#1578=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-440.000000000018));
#1579=LINE('',#1578,#1577);
#1580=EDGE_CURVE('E1212',#1488,#1573,#1579,.T.);
#1581=ORIENTED_EDGE('',*,*,#1580,.F.);
#1582=ORIENTED_EDGE('',*,*,#1489,.F.);
#1583=ORIENTED_EDGE('',*,*,#897,.F.);
#1584=ORIENTED_EDGE('',*,*,#1556,.F.);
#1585=DIRECTION('',(1.,0.,0.));
#1586=VECTOR('',#1585,1.);
#1587=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-440.000000000018));
#1588=LINE('',#1587,#1586);
#1589=EDGE_CURVE('E706',#1549,#1571,#1588,.F.);
#1590=ORIENTED_EDGE('',*,*,#1589,.T.);
#1591=EDGE_LOOP('',(#1575,#1581,#1582,#1583,#1584,#1590));
#1592=FACE_BOUND('',#1591,.T.);
#1593=ADVANCED_FACE('F1718',(#1592),#1565,.F.);
#1594=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-594.999999999906));
#1595=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#1596=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#1597=AXIS2_PLACEMENT_3D('',#1594,#1595,#1596);
#1598=PLANE('',#1597);
#1599=ORIENTED_EDGE('',*,*,#1574,.F.);
#1600=DIRECTION('',(0.,0.,1.));
#1601=VECTOR('',#1600,1.);
#1602=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-594.999999999906));
#1603=LINE('',#1602,#1601);
#1604=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,0.));
#1605=VERTEX_POINT('',#1604);
#1606=EDGE_CURVE('E1203',#1571,#1605,#1603,.T.);
#1607=ORIENTED_EDGE('',*,*,#1606,.T.);
#1608=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#1609=VECTOR('',#1608,1.);
#1610=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,0.));
#1611=LINE('',#1610,#1609);
#1612=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,0.));
#1613=VERTEX_POINT('',#1612);
#1614=EDGE_CURVE('E1335',#1613,#1605,#1611,.F.);
#1615=ORIENTED_EDGE('',*,*,#1614,.F.);
#1616=DIRECTION('',(0.,0.,-1.));
#1617=VECTOR('',#1616,1.);
#1618=CARTESIAN_POINT('',(40.4999999999904,-35.0000000000124,-594.999999999906));
#1619=LINE('',#1618,#1617);
#1620=EDGE_CURVE('E1359',#1573,#1613,#1619,.F.);
#1621=ORIENTED_EDGE('',*,*,#1620,.F.);
#1622=EDGE_LOOP('',(#1599,#1607,#1615,#1621));
#1623=FACE_BOUND('',#1622,.T.);
#1624=ADVANCED_FACE('F3234',(#1623),#1598,.F.);
#1625=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-594.999999999906));
#1626=DIRECTION('',(0.707106781186498,0.707106781186598,0.));
#1627=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#1628=AXIS2_PLACEMENT_3D('',#1625,#1626,#1627);
#1629=PLANE('',#1628);
#1630=DIRECTION('',(0.,0.,-1.));
#1631=VECTOR('',#1630,1.);
#1632=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-594.999999999906));
#1633=LINE('',#1632,#1631);
#1634=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,0.));
#1635=VERTEX_POINT('',#1634);
#1636=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-442.00000000001));
#1637=VERTEX_POINT('',#1636);
#1638=EDGE_CURVE('E1344',#1635,#1637,#1633,.T.);
#1639=ORIENTED_EDGE('',*,*,#1638,.F.);
#1640=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#1641=VECTOR('',#1640,1.);
#1642=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,0.));
#1643=LINE('',#1642,#1641);
#1644=CARTESIAN_POINT('',(51.4999999999929,-33.9999999999953,0.));
#1645=VERTEX_POINT('',#1644);
#1646=EDGE_CURVE('E1349',#1645,#1635,#1643,.F.);
#1647=ORIENTED_EDGE('',*,*,#1646,.F.);
#1648=DIRECTION('',(0.,0.,1.));
#1649=VECTOR('',#1648,1.);
#1650=CARTESIAN_POINT('',(51.4999999999972,-33.999999999991,-594.999999999906));
#1651=LINE('',#1650,#1649);
#1652=CARTESIAN_POINT('',(51.4999999999972,-33.999999999991,-442.00000000001));
#1653=VERTEX_POINT('',#1652);
#1654=EDGE_CURVE('E1208',#1645,#1653,#1651,.F.);
#1655=ORIENTED_EDGE('',*,*,#1654,.T.);
#1656=DIRECTION('',(-0.707106781177556,0.707106781195539,0.));
#1657=VECTOR('',#1656,1.);
#1658=CARTESIAN_POINT('',(52.4999999999932,-35.0000000000124,-442.00000000001));
#1659=LINE('',#1658,#1657);
#1660=EDGE_CURVE('E1353',#1637,#1653,#1659,.T.);
#1661=ORIENTED_EDGE('',*,*,#1660,.F.);
#1662=EDGE_LOOP('',(#1639,#1647,#1655,#1661));
#1663=FACE_BOUND('',#1662,.T.);
#1664=ADVANCED_FACE('F1712',(#1663),#1629,.F.);
#1665=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-442.00000000001));
#1666=DIRECTION('',(0.,0.,-1.));
#1667=DIRECTION('',(-1.,0.,0.));
#1668=AXIS2_PLACEMENT_3D('',#1665,#1666,#1667);
#1669=PLANE('',#1668);
#1670=DIRECTION('',(0.,1.,0.));
#1671=VECTOR('',#1670,1.);
#1672=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-442.00000000001));
#1673=LINE('',#1672,#1671);
#1674=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-442.00000000001));
#1675=VERTEX_POINT('',#1674);
#1676=CARTESIAN_POINT('',(84.9999999999902,-30.000000000007,-442.00000000001));
#1677=VERTEX_POINT('',#1676);
#1678=EDGE_CURVE('E1199',#1675,#1677,#1673,.T.);
#1679=ORIENTED_EDGE('',*,*,#1678,.F.);
#1680=DIRECTION('',(1.,0.,0.));
#1681=VECTOR('',#1680,1.);
#1682=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-442.00000000001));
#1683=LINE('',#1682,#1681);
#1684=EDGE_CURVE('E1200',#1637,#1675,#1683,.T.);
#1685=ORIENTED_EDGE('',*,*,#1684,.F.);
#1686=ORIENTED_EDGE('',*,*,#1660,.T.);
#1687=DIRECTION('',(1.,0.,0.));
#1688=VECTOR('',#1687,1.);
#1689=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-442.00000000001));
#1690=LINE('',#1689,#1688);
#1691=EDGE_CURVE('E707',#1653,#1540,#1690,.F.);
#1692=ORIENTED_EDGE('',*,*,#1691,.T.);
#1693=ORIENTED_EDGE('',*,*,#1541,.T.);
#1694=DIRECTION('',(1.,0.,0.));
#1695=VECTOR('',#1694,1.);
#1696=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-442.00000000001));
#1697=LINE('',#1696,#1695);
#1698=EDGE_CURVE('E790',#1677,#1532,#1697,.F.);
#1699=ORIENTED_EDGE('',*,*,#1698,.F.);
#1700=EDGE_LOOP('',(#1679,#1685,#1686,#1692,#1693,#1699));
#1701=FACE_BOUND('',#1700,.T.);
#1702=ADVANCED_FACE('F1700',(#1701),#1669,.T.);
#1703=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-457.999999999946));
#1704=DIRECTION('',(0.,-1.,0.));
#1705=DIRECTION('',(0.,0.,-1.));
#1706=AXIS2_PLACEMENT_3D('',#1703,#1704,#1705);
#1707=PLANE('',#1706);
#1708=ORIENTED_EDGE('',*,*,#579,.T.);
#1709=EDGE_LOOP('',(#1708));
#1710=FACE_BOUND('',#1709,.T.);
#1711=ORIENTED_EDGE('',*,*,#1533,.T.);
#1712=DIRECTION('',(1.,0.,0.));
#1713=VECTOR('',#1712,1.);
#1714=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-457.999999999946));
#1715=LINE('',#1714,#1713);
#1716=CARTESIAN_POINT('',(84.9999999999902,-30.000000000007,-457.999999999946));
#1717=VERTEX_POINT('',#1716);
#1718=EDGE_CURVE('E787',#1717,#1523,#1715,.F.);
#1719=ORIENTED_EDGE('',*,*,#1718,.F.);
#1720=DIRECTION('',(0.,0.,-1.));
#1721=VECTOR('',#1720,1.);
#1722=CARTESIAN_POINT('',(84.9999999999902,-30.000000000007,-594.999999999906));
#1723=LINE('',#1722,#1721);
#1724=EDGE_CURVE('E1608',#1677,#1717,#1723,.T.);
#1725=ORIENTED_EDGE('',*,*,#1724,.F.);
#1726=ORIENTED_EDGE('',*,*,#1698,.T.);
#1727=EDGE_LOOP('',(#1711,#1719,#1725,#1726));
#1728=FACE_BOUND('',#1727,.T.);
#1729=ADVANCED_FACE('F1695',(#1710,#1728),#1707,.T.);
#1730=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-457.999999999946));
#1731=DIRECTION('',(0.,0.,1.));
#1732=DIRECTION('',(1.,0.,0.));
#1733=AXIS2_PLACEMENT_3D('',#1730,#1731,#1732);
#1734=PLANE('',#1733);
#1735=ORIENTED_EDGE('',*,*,#1059,.T.);
#1736=DIRECTION('',(1.,0.,0.));
#1737=VECTOR('',#1736,1.);
#1738=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-457.999999999946));
#1739=LINE('',#1738,#1737);
#1740=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-457.999999999946));
#1741=VERTEX_POINT('',#1740);
#1742=EDGE_CURVE('E1254',#1741,#1052,#1739,.F.);
#1743=ORIENTED_EDGE('',*,*,#1742,.F.);
#1744=DIRECTION('',(0.,1.,0.));
#1745=VECTOR('',#1744,1.);
#1746=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-457.999999999946));
#1747=LINE('',#1746,#1745);
#1748=EDGE_CURVE('E1195',#1717,#1741,#1747,.F.);
#1749=ORIENTED_EDGE('',*,*,#1748,.F.);
#1750=ORIENTED_EDGE('',*,*,#1718,.T.);
#1751=ORIENTED_EDGE('',*,*,#1524,.T.);
#1752=DIRECTION('',(1.,0.,0.));
#1753=VECTOR('',#1752,1.);
#1754=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-457.999999999946));
#1755=LINE('',#1754,#1753);
#1756=EDGE_CURVE('E747',#1515,#1034,#1755,.T.);
#1757=ORIENTED_EDGE('',*,*,#1756,.T.);
#1758=EDGE_LOOP('',(#1735,#1743,#1749,#1750,#1751,#1757));
#1759=FACE_BOUND('',#1758,.T.);
#1760=ADVANCED_FACE('F1688',(#1759),#1734,.T.);
#1761=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-527.99999999992));
#1762=DIRECTION('',(0.,1.,0.));
#1763=DIRECTION('',(0.,0.,1.));
#1764=AXIS2_PLACEMENT_3D('',#1761,#1762,#1763);
#1765=CYLINDRICAL_SURFACE('',#1764,10.0000000000006);
#1766=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-527.99999999992));
#1767=DIRECTION('',(0.,1.,0.));
#1768=DIRECTION('',(0.,0.,1.));
#1769=AXIS2_PLACEMENT_3D('',#1766,#1767,#1768);
#1770=CIRCLE('',#1769,10.0000000000006);
#1771=CARTESIAN_POINT('',(59.9999999999886,35.0000000000124,-517.999999999919));
#1772=VERTEX_POINT('',#1771);
#1773=EDGE_CURVE('E698',#1772,#1772,#1770,.F.);
#1774=ORIENTED_EDGE('',*,*,#1773,.F.);
#1775=EDGE_LOOP('',(#1774));
#1776=FACE_BOUND('',#1775,.T.);
#1777=ORIENTED_EDGE('',*,*,#602,.F.);
#1778=EDGE_LOOP('',(#1777));
#1779=FACE_BOUND('',#1778,.T.);
#1780=ADVANCED_FACE('F3271',(#1776,#1779),#1765,.F.);
#1781=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-558.000000000054));
#1782=DIRECTION('',(0.,0.,1.));
#1783=DIRECTION('',(1.,0.,0.));
#1784=AXIS2_PLACEMENT_3D('',#1781,#1782,#1783);
#1785=PLANE('',#1784);
#1786=DIRECTION('',(0.,1.,0.));
#1787=VECTOR('',#1786,1.);
#1788=CARTESIAN_POINT('',(30.500000000005,28.4641016151424,-558.000000000054));
#1789=LINE('',#1788,#1787);
#1790=CARTESIAN_POINT('',(30.500000000005,35.0000000000124,-558.000000000054));
#1791=VERTEX_POINT('',#1790);
#1792=CARTESIAN_POINT('',(30.500000000005,30.000000000007,-558.000000000054));
#1793=VERTEX_POINT('',#1792);
#1794=EDGE_CURVE('E1167',#1791,#1793,#1789,.F.);
#1795=ORIENTED_EDGE('',*,*,#1794,.T.);
#1796=DIRECTION('',(1.,0.,0.));
#1797=VECTOR('',#1796,1.);
#1798=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-558.000000000054));
#1799=LINE('',#1798,#1797);
#1800=CARTESIAN_POINT('',(84.9999999999902,30.000000000007,-558.000000000054));
#1801=VERTEX_POINT('',#1800);
#1802=EDGE_CURVE('E782',#1801,#1793,#1799,.F.);
#1803=ORIENTED_EDGE('',*,*,#1802,.F.);
#1804=DIRECTION('',(0.,1.,0.));
#1805=VECTOR('',#1804,1.);
#1806=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-558.000000000054));
#1807=LINE('',#1806,#1805);
#1808=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-558.000000000054));
#1809=VERTEX_POINT('',#1808);
#1810=EDGE_CURVE('E1180',#1809,#1801,#1807,.F.);
#1811=ORIENTED_EDGE('',*,*,#1810,.F.);
#1812=DIRECTION('',(1.,0.,0.));
#1813=VECTOR('',#1812,1.);
#1814=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-558.000000000054));
#1815=LINE('',#1814,#1813);
#1816=EDGE_CURVE('E743',#1791,#1809,#1815,.T.);
#1817=ORIENTED_EDGE('',*,*,#1816,.F.);
#1818=EDGE_LOOP('',(#1795,#1803,#1811,#1817));
#1819=FACE_BOUND('',#1818,.T.);
#1820=ADVANCED_FACE('F1926',(#1819),#1785,.T.);
#1821=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-558.000000000054));
#1822=DIRECTION('',(0.,1.,0.));
#1823=DIRECTION('',(0.,0.,1.));
#1824=AXIS2_PLACEMENT_3D('',#1821,#1822,#1823);
#1825=PLANE('',#1824);
#1826=DIRECTION('',(0.,0.,-1.));
#1827=VECTOR('',#1826,1.);
#1828=CARTESIAN_POINT('',(30.500000000005,30.000000000007,-594.999999999906));
#1829=LINE('',#1828,#1827);
#1830=CARTESIAN_POINT('',(30.500000000005,30.000000000007,-542.000000000118));
#1831=VERTEX_POINT('',#1830);
#1832=EDGE_CURVE('E1164',#1793,#1831,#1829,.F.);
#1833=ORIENTED_EDGE('',*,*,#1832,.T.);
#1834=DIRECTION('',(-1.,0.,0.));
#1835=VECTOR('',#1834,1.);
#1836=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-542.000000000118));
#1837=LINE('',#1836,#1835);
#1838=CARTESIAN_POINT('',(84.9999999999902,30.000000000007,-542.000000000118));
#1839=VERTEX_POINT('',#1838);
#1840=EDGE_CURVE('E778',#1839,#1831,#1837,.T.);
#1841=ORIENTED_EDGE('',*,*,#1840,.F.);
#1842=DIRECTION('',(0.,0.,-1.));
#1843=VECTOR('',#1842,1.);
#1844=CARTESIAN_POINT('',(84.9999999999902,30.000000000007,-594.999999999906));
#1845=LINE('',#1844,#1843);
#1846=EDGE_CURVE('E1178',#1801,#1839,#1845,.F.);
#1847=ORIENTED_EDGE('',*,*,#1846,.F.);
#1848=ORIENTED_EDGE('',*,*,#1802,.T.);
#1849=EDGE_LOOP('',(#1833,#1841,#1847,#1848));
#1850=FACE_BOUND('',#1849,.T.);
#1851=ADVANCED_FACE('F1931',(#1850),#1825,.T.);
#1852=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-542.000000000118));
#1853=DIRECTION('',(0.,0.,-1.));
#1854=DIRECTION('',(-1.,0.,0.));
#1855=AXIS2_PLACEMENT_3D('',#1852,#1853,#1854);
#1856=PLANE('',#1855);
#1857=DIRECTION('',(0.,1.,0.));
#1858=VECTOR('',#1857,1.);
#1859=CARTESIAN_POINT('',(30.500000000005,28.4641016151424,-542.000000000118));
#1860=LINE('',#1859,#1858);
#1861=CARTESIAN_POINT('',(30.500000000005,35.0000000000124,-542.000000000118));
#1862=VERTEX_POINT('',#1861);
#1863=EDGE_CURVE('E1161',#1831,#1862,#1860,.T.);
#1864=ORIENTED_EDGE('',*,*,#1863,.T.);
#1865=DIRECTION('',(1.,0.,0.));
#1866=VECTOR('',#1865,1.);
#1867=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-542.000000000118));
#1868=LINE('',#1867,#1866);
#1869=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-542.000000000118));
#1870=VERTEX_POINT('',#1869);
#1871=EDGE_CURVE('E702',#1870,#1862,#1868,.F.);
#1872=ORIENTED_EDGE('',*,*,#1871,.F.);
#1873=DIRECTION('',(0.,1.,0.));
#1874=VECTOR('',#1873,1.);
#1875=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-542.000000000118));
#1876=LINE('',#1875,#1874);
#1877=EDGE_CURVE('E1176',#1839,#1870,#1876,.T.);
#1878=ORIENTED_EDGE('',*,*,#1877,.F.);
#1879=ORIENTED_EDGE('',*,*,#1840,.T.);
#1880=EDGE_LOOP('',(#1864,#1872,#1878,#1879));
#1881=FACE_BOUND('',#1880,.T.);
#1882=ADVANCED_FACE('F1939',(#1881),#1856,.T.);
#1883=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-527.99999999992));
#1884=DIRECTION('',(0.,1.,0.));
#1885=DIRECTION('',(0.,0.,1.));
#1886=AXIS2_PLACEMENT_3D('',#1883,#1884,#1885);
#1887=CYLINDRICAL_SURFACE('',#1886,10.0000000000006);
#1888=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-527.99999999992));
#1889=DIRECTION('',(0.,1.,0.));
#1890=DIRECTION('',(0.,0.,1.));
#1891=AXIS2_PLACEMENT_3D('',#1888,#1889,#1890);
#1892=CIRCLE('',#1891,10.0000000000006);
#1893=CARTESIAN_POINT('',(-59.9999999999886,35.0000000000124,-517.999999999919));
#1894=VERTEX_POINT('',#1893);
#1895=EDGE_CURVE('E693',#1894,#1894,#1892,.F.);
#1896=ORIENTED_EDGE('',*,*,#1895,.F.);
#1897=EDGE_LOOP('',(#1896));
#1898=FACE_BOUND('',#1897,.T.);
#1899=ORIENTED_EDGE('',*,*,#622,.F.);
#1900=EDGE_LOOP('',(#1899));
#1901=FACE_BOUND('',#1900,.T.);
#1902=ADVANCED_FACE('F1942',(#1898,#1901),#1887,.F.);
#1903=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-542.000000000118));
#1904=DIRECTION('',(0.,0.,-1.));
#1905=DIRECTION('',(-1.,0.,0.));
#1906=AXIS2_PLACEMENT_3D('',#1903,#1904,#1905);
#1907=PLANE('',#1906);
#1908=DIRECTION('',(0.,1.,0.));
#1909=VECTOR('',#1908,1.);
#1910=CARTESIAN_POINT('',(-30.500000000005,28.4641016151424,-542.000000000118));
#1911=LINE('',#1910,#1909);
#1912=CARTESIAN_POINT('',(-30.500000000005,35.0000000000124,-542.000000000118));
#1913=VERTEX_POINT('',#1912);
#1914=CARTESIAN_POINT('',(-30.500000000005,30.000000000007,-542.000000000118));
#1915=VERTEX_POINT('',#1914);
#1916=EDGE_CURVE('E1122',#1913,#1915,#1911,.F.);
#1917=ORIENTED_EDGE('',*,*,#1916,.T.);
#1918=DIRECTION('',(1.,0.,0.));
#1919=VECTOR('',#1918,1.);
#1920=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-542.000000000118));
#1921=LINE('',#1920,#1919);
#1922=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-542.000000000118));
#1923=VERTEX_POINT('',#1922);
#1924=EDGE_CURVE('E777',#1923,#1915,#1921,.T.);
#1925=ORIENTED_EDGE('',*,*,#1924,.F.);
#1926=DIRECTION('',(0.,1.,0.));
#1927=VECTOR('',#1926,1.);
#1928=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-542.000000000118));
#1929=LINE('',#1928,#1927);
#1930=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-542.000000000118));
#1931=VERTEX_POINT('',#1930);
#1932=EDGE_CURVE('E1103',#1931,#1923,#1929,.F.);
#1933=ORIENTED_EDGE('',*,*,#1932,.F.);
#1934=DIRECTION('',(1.,0.,0.));
#1935=VECTOR('',#1934,1.);
#1936=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-542.000000000118));
#1937=LINE('',#1936,#1935);
#1938=EDGE_CURVE('E697',#1913,#1931,#1937,.F.);
#1939=ORIENTED_EDGE('',*,*,#1938,.F.);
#1940=EDGE_LOOP('',(#1917,#1925,#1933,#1939));
#1941=FACE_BOUND('',#1940,.T.);
#1942=ADVANCED_FACE('F1846',(#1941),#1907,.T.);
#1943=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-558.000000000054));
#1944=DIRECTION('',(0.,1.,0.));
#1945=DIRECTION('',(0.,0.,1.));
#1946=AXIS2_PLACEMENT_3D('',#1943,#1944,#1945);
#1947=PLANE('',#1946);
#1948=DIRECTION('',(0.,0.,1.));
#1949=VECTOR('',#1948,1.);
#1950=CARTESIAN_POINT('',(-30.500000000005,30.000000000007,-594.999999999906));
#1951=LINE('',#1950,#1949);
#1952=CARTESIAN_POINT('',(-30.500000000005,30.000000000007,-558.000000000054));
#1953=VERTEX_POINT('',#1952);
#1954=EDGE_CURVE('E1119',#1915,#1953,#1951,.F.);
#1955=ORIENTED_EDGE('',*,*,#1954,.T.);
#1956=DIRECTION('',(1.,0.,0.));
#1957=VECTOR('',#1956,1.);
#1958=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-558.000000000054));
#1959=LINE('',#1958,#1957);
#1960=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-558.000000000054));
#1961=VERTEX_POINT('',#1960);
#1962=EDGE_CURVE('E1325',#1961,#1953,#1959,.T.);
#1963=ORIENTED_EDGE('',*,*,#1962,.F.);
#1964=DIRECTION('',(0.,0.,1.));
#1965=VECTOR('',#1964,1.);
#1966=CARTESIAN_POINT('',(-84.9999999999902,30.000000000007,-594.999999999906));
#1967=LINE('',#1966,#1965);
#1968=EDGE_CURVE('E1101',#1923,#1961,#1967,.F.);
#1969=ORIENTED_EDGE('',*,*,#1968,.F.);
#1970=ORIENTED_EDGE('',*,*,#1924,.T.);
#1971=EDGE_LOOP('',(#1955,#1963,#1969,#1970));
#1972=FACE_BOUND('',#1971,.T.);
#1973=ADVANCED_FACE('F1841',(#1972),#1947,.T.);
#1974=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-558.000000000054));
#1975=DIRECTION('',(0.,0.,1.));
#1976=DIRECTION('',(1.,0.,0.));
#1977=AXIS2_PLACEMENT_3D('',#1974,#1975,#1976);
#1978=PLANE('',#1977);
#1979=DIRECTION('',(0.,1.,0.));
#1980=VECTOR('',#1979,1.);
#1981=CARTESIAN_POINT('',(-30.500000000005,28.4641016151424,-558.000000000054));
#1982=LINE('',#1981,#1980);
#1983=CARTESIAN_POINT('',(-30.500000000005,35.0000000000124,-558.000000000054));
#1984=VERTEX_POINT('',#1983);
#1985=EDGE_CURVE('E1116',#1953,#1984,#1982,.T.);
#1986=ORIENTED_EDGE('',*,*,#1985,.T.);
#1987=DIRECTION('',(1.,0.,0.));
#1988=VECTOR('',#1987,1.);
#1989=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-558.000000000054));
#1990=LINE('',#1989,#1988);
#1991=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-558.000000000054));
#1992=VERTEX_POINT('',#1991);
#1993=EDGE_CURVE('E739',#1992,#1984,#1990,.T.);
#1994=ORIENTED_EDGE('',*,*,#1993,.F.);
#1995=DIRECTION('',(0.,1.,0.));
#1996=VECTOR('',#1995,1.);
#1997=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-558.000000000054));
#1998=LINE('',#1997,#1996);
#1999=EDGE_CURVE('E1099',#1961,#1992,#1998,.T.);
#2000=ORIENTED_EDGE('',*,*,#1999,.F.);
#2001=ORIENTED_EDGE('',*,*,#1962,.T.);
#2002=EDGE_LOOP('',(#1986,#1994,#2000,#2001));
#2003=FACE_BOUND('',#2002,.T.);
#2004=ADVANCED_FACE('F1836',(#2003),#1978,.T.);
#2005=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-457.999999999946));
#2006=DIRECTION('',(0.,0.,1.));
#2007=DIRECTION('',(1.,0.,0.));
#2008=AXIS2_PLACEMENT_3D('',#2005,#2006,#2007);
#2009=PLANE('',#2008);
#2010=DIRECTION('',(0.,1.,0.));
#2011=VECTOR('',#2010,1.);
#2012=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-457.999999999946));
#2013=LINE('',#2012,#2011);
#2014=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-457.999999999946));
#2015=VERTEX_POINT('',#2014);
#2016=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-457.999999999946));
#2017=VERTEX_POINT('',#2016);
#2018=EDGE_CURVE('E1088',#2015,#2017,#2013,.T.);
#2019=ORIENTED_EDGE('',*,*,#2018,.F.);
#2020=DIRECTION('',(1.,0.,0.));
#2021=VECTOR('',#2020,1.);
#2022=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-457.999999999946));
#2023=LINE('',#2022,#2021);
#2024=EDGE_CURVE('E1249',#1116,#2015,#2023,.F.);
#2025=ORIENTED_EDGE('',*,*,#2024,.F.);
#2026=ORIENTED_EDGE('',*,*,#1139,.T.);
#2027=DIRECTION('',(1.,0.,0.));
#2028=VECTOR('',#2027,1.);
#2029=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-457.999999999946));
#2030=LINE('',#2029,#2028);
#2031=CARTESIAN_POINT('',(-51.000000000028,-33.999999999991,-457.999999999956));
#2032=VERTEX_POINT('',#2031);
#2033=EDGE_CURVE('E734',#1132,#2032,#2030,.T.);
#2034=ORIENTED_EDGE('',*,*,#2033,.T.);
#2035=DIRECTION('',(0.,-1.,0.));
#2036=VECTOR('',#2035,1.);
#2037=CARTESIAN_POINT('',(-51.0000000000144,-29.5000000000344,-457.999999999966));
#2038=LINE('',#2037,#2036);
#2039=CARTESIAN_POINT('',(-51.000000000028,-30.000000000007,-457.999999999956));
#2040=VERTEX_POINT('',#2039);
#2041=EDGE_CURVE('E768',#2032,#2040,#2038,.F.);
#2042=ORIENTED_EDGE('',*,*,#2041,.T.);
#2043=DIRECTION('',(1.,0.,0.));
#2044=VECTOR('',#2043,1.);
#2045=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-457.999999999946));
#2046=LINE('',#2045,#2044);
#2047=EDGE_CURVE('E773',#2017,#2040,#2046,.T.);
#2048=ORIENTED_EDGE('',*,*,#2047,.F.);
#2049=EDGE_LOOP('',(#2019,#2025,#2026,#2034,#2042,#2048));
#2050=FACE_BOUND('',#2049,.T.);
#2051=ADVANCED_FACE('F1780',(#2050),#2009,.T.);
#2052=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-457.999999999946));
#2053=DIRECTION('',(0.,-1.,0.));
#2054=DIRECTION('',(0.,0.,-1.));
#2055=AXIS2_PLACEMENT_3D('',#2052,#2053,#2054);
#2056=PLANE('',#2055);
#2057=ORIENTED_EDGE('',*,*,#639,.T.);
#2058=EDGE_LOOP('',(#2057));
#2059=FACE_BOUND('',#2058,.T.);
#2060=CARTESIAN_POINT('',(-44.9999999999978,-30.000000000007,-449.999999999978));
#2061=DIRECTION('',(0.,-1.,0.));
#2062=DIRECTION('',(0.,0.,-1.));
#2063=AXIS2_PLACEMENT_3D('',#2060,#2061,#2062);
#2064=CIRCLE('',#2063,10.0000000000006);
#2065=CARTESIAN_POINT('',(-51.0000000000281,-30.000000000007,-442.));
#2066=VERTEX_POINT('',#2065);
#2067=EDGE_CURVE('E764',#2040,#2066,#2064,.F.);
#2068=ORIENTED_EDGE('',*,*,#2067,.T.);
#2069=DIRECTION('',(-1.,0.,0.));
#2070=VECTOR('',#2069,1.);
#2071=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-442.00000000001));
#2072=LINE('',#2071,#2070);
#2073=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-442.00000000001));
#2074=VERTEX_POINT('',#2073);
#2075=EDGE_CURVE('E772',#2074,#2066,#2072,.F.);
#2076=ORIENTED_EDGE('',*,*,#2075,.F.);
#2077=DIRECTION('',(0.,0.,1.));
#2078=VECTOR('',#2077,1.);
#2079=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-594.999999999906));
#2080=LINE('',#2079,#2078);
#2081=EDGE_CURVE('E1580',#2017,#2074,#2080,.T.);
#2082=ORIENTED_EDGE('',*,*,#2081,.F.);
#2083=ORIENTED_EDGE('',*,*,#2047,.T.);
#2084=EDGE_LOOP('',(#2068,#2076,#2082,#2083));
#2085=FACE_BOUND('',#2084,.T.);
#2086=ADVANCED_FACE('F1775',(#2059,#2085),#2056,.T.);
#2087=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-442.00000000001));
#2088=DIRECTION('',(0.,0.,-1.));
#2089=DIRECTION('',(-1.,0.,0.));
#2090=AXIS2_PLACEMENT_3D('',#2087,#2088,#2089);
#2091=PLANE('',#2090);
#2092=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#2093=VECTOR('',#2092,1.);
#2094=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-442.00000000001));
#2095=LINE('',#2094,#2093);
#2096=CARTESIAN_POINT('',(-51.499999999994,-33.999999999991,-442.00000000001));
#2097=VERTEX_POINT('',#2096);
#2098=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-442.00000000001));
#2099=VERTEX_POINT('',#2098);
#2100=EDGE_CURVE('E1296',#2097,#2099,#2095,.T.);
#2101=ORIENTED_EDGE('',*,*,#2100,.T.);
#2102=DIRECTION('',(1.,0.,0.));
#2103=VECTOR('',#2102,1.);
#2104=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-442.00000000001));
#2105=LINE('',#2104,#2103);
#2106=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-442.00000000001));
#2107=VERTEX_POINT('',#2106);
#2108=EDGE_CURVE('E1075',#2107,#2099,#2105,.T.);
#2109=ORIENTED_EDGE('',*,*,#2108,.F.);
#2110=DIRECTION('',(0.,1.,0.));
#2111=VECTOR('',#2110,1.);
#2112=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-442.00000000001));
#2113=LINE('',#2112,#2111);
#2114=EDGE_CURVE('E1084',#2074,#2107,#2113,.F.);
#2115=ORIENTED_EDGE('',*,*,#2114,.F.);
#2116=ORIENTED_EDGE('',*,*,#2075,.T.);
#2117=DIRECTION('',(0.,-1.,0.));
#2118=VECTOR('',#2117,1.);
#2119=CARTESIAN_POINT('',(-51.0000000000145,-29.5000000000344,-441.99999999999));
#2120=LINE('',#2119,#2118);
#2121=CARTESIAN_POINT('',(-51.0000000000281,-33.999999999991,-442.));
#2122=VERTEX_POINT('',#2121);
#2123=EDGE_CURVE('E767',#2066,#2122,#2120,.T.);
#2124=ORIENTED_EDGE('',*,*,#2123,.T.);
#2125=DIRECTION('',(-1.,0.,0.));
#2126=VECTOR('',#2125,1.);
#2127=CARTESIAN_POINT('',(-84.9999999999902,-33.999999999991,-442.00000000001));
#2128=LINE('',#2127,#2126);
#2129=EDGE_CURVE('E1314',#2122,#2097,#2128,.T.);
#2130=ORIENTED_EDGE('',*,*,#2129,.T.);
#2131=EDGE_LOOP('',(#2101,#2109,#2115,#2116,#2124,#2130));
#2132=FACE_BOUND('',#2131,.T.);
#2133=ADVANCED_FACE('F1770',(#2132),#2091,.T.);
#2134=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-594.999999999906));
#2135=DIRECTION('',(0.707106781186548,0.707106781186548,0.));
#2136=DIRECTION('',(-0.707106781186548,0.707106781186548,0.));
#2137=AXIS2_PLACEMENT_3D('',#2134,#2135,#2136);
#2138=PLANE('',#2137);
#2139=DIRECTION('',(0.707106781186545,-0.70710678118655,0.));
#2140=VECTOR('',#2139,1.);
#2141=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-440.000000000018));
#2142=LINE('',#2141,#2140);
#2143=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-440.000000000018));
#2144=VERTEX_POINT('',#2143);
#2145=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-440.000000000018));
#2146=VERTEX_POINT('',#2145);
#2147=EDGE_CURVE('E1301',#2144,#2146,#2142,.T.);
#2148=ORIENTED_EDGE('',*,*,#2147,.T.);
#2149=DIRECTION('',(0.,0.,-1.));
#2150=VECTOR('',#2149,1.);
#2151=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,-594.999999999906));
#2152=LINE('',#2151,#2150);
#2153=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,0.));
#2154=VERTEX_POINT('',#2153);
#2155=EDGE_CURVE('E721',#2154,#2146,#2152,.T.);
#2156=ORIENTED_EDGE('',*,*,#2155,.F.);
#2157=DIRECTION('',(-0.707106781186548,0.707106781186548,0.));
#2158=VECTOR('',#2157,1.);
#2159=CARTESIAN_POINT('',(-40.4999999999904,-35.0000000000124,2.22044604925031E-13));
#2160=LINE('',#2159,#2158);
#2161=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,0.));
#2162=VERTEX_POINT('',#2161);
#2163=EDGE_CURVE('E1311',#2162,#2154,#2160,.F.);
#2164=ORIENTED_EDGE('',*,*,#2163,.F.);
#2165=DIRECTION('',(0.,0.,1.));
#2166=VECTOR('',#2165,1.);
#2167=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-594.999999999906));
#2168=LINE('',#2167,#2166);
#2169=EDGE_CURVE('E1072',#2162,#2144,#2168,.F.);
#2170=ORIENTED_EDGE('',*,*,#2169,.T.);
#2171=EDGE_LOOP('',(#2148,#2156,#2164,#2170));
#2172=FACE_BOUND('',#2171,.T.);
#2173=ADVANCED_FACE('F2171',(#2172),#2138,.F.);
#2174=CARTESIAN_POINT('',(44.9999999999978,-29.5000000000344,-440.000000000018));
#2175=DIRECTION('',(0.,0.,1.));
#2176=DIRECTION('',(1.,0.,0.));
#2177=AXIS2_PLACEMENT_3D('',#2174,#2175,#2176);
#2178=PLANE('',#2177);
#2179=ORIENTED_EDGE('',*,*,#2147,.F.);
#2180=DIRECTION('',(1.,0.,0.));
#2181=VECTOR('',#2180,1.);
#2182=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-440.000000000018));
#2183=LINE('',#2182,#2181);
#2184=CARTESIAN_POINT('',(-44.9999999999978,-33.999999999991,-439.999999999998));
#2185=VERTEX_POINT('',#2184);
#2186=EDGE_CURVE('E692',#2144,#2185,#2183,.F.);
#2187=ORIENTED_EDGE('',*,*,#2186,.T.);
#2188=DIRECTION('',(0.,-1.,0.));
#2189=VECTOR('',#2188,1.);
#2190=CARTESIAN_POINT('',(-44.9999999999978,-29.5000000000344,-439.999999999977));
#2191=LINE('',#2190,#2189);
#2192=EDGE_CURVE('E763',#2185,#831,#2191,.F.);
#2193=ORIENTED_EDGE('',*,*,#2192,.T.);
#2194=ORIENTED_EDGE('',*,*,#832,.F.);
#2195=ORIENTED_EDGE('',*,*,#1340,.F.);
#2196=DIRECTION('',(1.,0.,0.));
#2197=VECTOR('',#2196,1.);
#2198=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-440.000000000018));
#2199=LINE('',#2198,#2197);
#2200=EDGE_CURVE('E1229',#2146,#1339,#2199,.T.);
#2201=ORIENTED_EDGE('',*,*,#2200,.F.);
#2202=EDGE_LOOP('',(#2179,#2187,#2193,#2194,#2195,#2201));
#2203=FACE_BOUND('',#2202,.T.);
#2204=ADVANCED_FACE('F1756',(#2203),#2178,.F.);
#2205=CARTESIAN_POINT('',(-44.9999999999978,-29.5000000000344,-449.999999999978));
#2206=DIRECTION('',(0.,-1.,0.));
#2207=DIRECTION('',(0.,0.,-1.));
#2208=AXIS2_PLACEMENT_3D('',#2205,#2206,#2207);
#2209=CYLINDRICAL_SURFACE('',#2208,10.0000000000006);
#2210=ORIENTED_EDGE('',*,*,#841,.F.);
#2211=ORIENTED_EDGE('',*,*,#2192,.F.);
#2212=CARTESIAN_POINT('',(-44.9999999999978,-33.999999999991,-449.999999999978));
#2213=DIRECTION('',(0.,-1.,0.));
#2214=DIRECTION('',(0.,0.,-1.));
#2215=AXIS2_PLACEMENT_3D('',#2212,#2213,#2214);
#2216=CIRCLE('',#2215,10.0000000000006);
#2217=EDGE_CURVE('E688',#2185,#2122,#2216,.T.);
#2218=ORIENTED_EDGE('',*,*,#2217,.T.);
#2219=ORIENTED_EDGE('',*,*,#2123,.F.);
#2220=ORIENTED_EDGE('',*,*,#2067,.F.);
#2221=ORIENTED_EDGE('',*,*,#2041,.F.);
#2222=CARTESIAN_POINT('',(-44.9999999999978,-33.999999999991,-449.999999999978));
#2223=DIRECTION('',(0.,-1.,0.));
#2224=DIRECTION('',(0.,0.,-1.));
#2225=AXIS2_PLACEMENT_3D('',#2222,#2223,#2224);
#2226=CIRCLE('',#2225,10.0000000000006);
#2227=EDGE_CURVE('E730',#2032,#1255,#2226,.T.);
#2228=ORIENTED_EDGE('',*,*,#2227,.T.);
#2229=ORIENTED_EDGE('',*,*,#1256,.F.);
#2230=EDGE_LOOP('',(#2210,#2211,#2218,#2219,#2220,#2221,#2228,#2229));
#2231=FACE_BOUND('',#2230,.T.);
#2232=ADVANCED_FACE('F1760',(#2231),#2209,.F.);
#2233=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-594.999999999906));
#2234=DIRECTION('',(-0.707106781186598,0.707106781186498,0.));
#2235=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#2236=AXIS2_PLACEMENT_3D('',#2233,#2234,#2235);
#2237=PLANE('',#2236);
#2238=DIRECTION('',(0.,0.,1.));
#2239=VECTOR('',#2238,1.);
#2240=CARTESIAN_POINT('',(-51.4999999999972,-33.999999999991,-594.999999999906));
#2241=LINE('',#2240,#2239);
#2242=CARTESIAN_POINT('',(-51.4999999999909,-33.9999999999973,0.));
#2243=VERTEX_POINT('',#2242);
#2244=EDGE_CURVE('E691',#2097,#2243,#2241,.T.);
#2245=ORIENTED_EDGE('',*,*,#2244,.T.);
#2246=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#2247=VECTOR('',#2246,1.);
#2248=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,0.));
#2249=LINE('',#2248,#2247);
#2250=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,0.));
#2251=VERTEX_POINT('',#2250);
#2252=EDGE_CURVE('E1294',#2251,#2243,#2249,.F.);
#2253=ORIENTED_EDGE('',*,*,#2252,.F.);
#2254=DIRECTION('',(0.,0.,-1.));
#2255=VECTOR('',#2254,1.);
#2256=CARTESIAN_POINT('',(-52.4999999999932,-35.0000000000124,-594.999999999906));
#2257=LINE('',#2256,#2255);
#2258=EDGE_CURVE('E1081',#2099,#2251,#2257,.F.);
#2259=ORIENTED_EDGE('',*,*,#2258,.F.);
#2260=ORIENTED_EDGE('',*,*,#2100,.F.);
#2261=EDGE_LOOP('',(#2245,#2253,#2259,#2260));
#2262=FACE_BOUND('',#2261,.T.);
#2263=ADVANCED_FACE('F2162',(#2262),#2237,.F.);
#2264=CARTESIAN_POINT('',(0.,-4.38000000001296,-69.0000000000034));
#2265=DIRECTION('',(0.,1.,0.));
#2266=DIRECTION('',(0.,0.,1.));
#2267=AXIS2_PLACEMENT_3D('',#2264,#2265,#2266);
#2268=CYLINDRICAL_SURFACE('',#2267,5.00000000000032);
#2269=CARTESIAN_POINT('',(0.,-12.3800000000102,-69.0000000000034));
#2270=DIRECTION('',(0.,1.,0.));
#2271=DIRECTION('',(0.,0.,1.));
#2272=AXIS2_PLACEMENT_3D('',#2269,#2270,#2271);
#2273=CIRCLE('',#2272,5.00000000000415);
#2274=CARTESIAN_POINT('',(0.,-12.3800000000102,-63.9999999999992));
#2275=VERTEX_POINT('',#2274);
#2276=EDGE_CURVE('E1291',#2275,#2275,#2273,.T.);
#2277=ORIENTED_EDGE('',*,*,#2276,.T.);
#2278=EDGE_LOOP('',(#2277));
#2279=FACE_BOUND('',#2278,.T.);
#2280=ORIENTED_EDGE('',*,*,#659,.F.);
#2281=EDGE_LOOP('',(#2280));
#2282=FACE_BOUND('',#2281,.T.);
#2283=ADVANCED_FACE('F2158',(#2279,#2282),#2268,.F.);
#2284=CARTESIAN_POINT('',(0.,-4.38000000001296,-109.499999999994));
#2285=DIRECTION('',(0.,1.,0.));
#2286=DIRECTION('',(0.,0.,1.));
#2287=AXIS2_PLACEMENT_3D('',#2284,#2285,#2286);
#2288=CYLINDRICAL_SURFACE('',#2287,5.00000000000032);
#2289=CARTESIAN_POINT('',(0.,-12.3800000000102,-109.499999999994));
#2290=DIRECTION('',(0.,1.,0.));
#2291=DIRECTION('',(0.,0.,1.));
#2292=AXIS2_PLACEMENT_3D('',#2289,#2290,#2291);
#2293=CIRCLE('',#2292,5.00000000000415);
#2294=CARTESIAN_POINT('',(0.,-12.3800000000102,-104.49999999999));
#2295=VERTEX_POINT('',#2294);
#2296=EDGE_CURVE('E1288',#2295,#2295,#2293,.T.);
#2297=ORIENTED_EDGE('',*,*,#2296,.T.);
#2298=EDGE_LOOP('',(#2297));
#2299=FACE_BOUND('',#2298,.T.);
#2300=ORIENTED_EDGE('',*,*,#680,.F.);
#2301=EDGE_LOOP('',(#2300));
#2302=FACE_BOUND('',#2301,.T.);
#2303=ADVANCED_FACE('F2154',(#2299,#2302),#2288,.F.);
#2304=CARTESIAN_POINT('',(0.,-4.38000000001296,-183.333333333311));
#2305=DIRECTION('',(0.,1.,0.));
#2306=DIRECTION('',(0.,0.,1.));
#2307=AXIS2_PLACEMENT_3D('',#2304,#2305,#2306);
#2308=CYLINDRICAL_SURFACE('',#2307,5.00000000000032);
#2309=CARTESIAN_POINT('',(0.,-12.3800000000102,-183.333333333311));
#2310=DIRECTION('',(0.,1.,0.));
#2311=DIRECTION('',(-1.,0.,0.));
#2312=AXIS2_PLACEMENT_3D('',#2309,#2310,#2311);
#2313=CIRCLE('',#2312,5.00000000000415);
#2314=CARTESIAN_POINT('',(-5.00000000000415,-12.3800000000102,-183.333333333311));
#2315=VERTEX_POINT('',#2314);
#2316=EDGE_CURVE('E1285',#2315,#2315,#2313,.T.);
#2317=ORIENTED_EDGE('',*,*,#2316,.T.);
#2318=EDGE_LOOP('',(#2317));
#2319=FACE_BOUND('',#2318,.T.);
#2320=ORIENTED_EDGE('',*,*,#701,.F.);
#2321=EDGE_LOOP('',(#2320));
#2322=FACE_BOUND('',#2321,.T.);
#2323=ADVANCED_FACE('F2150',(#2319,#2322),#2308,.F.);
#2324=CARTESIAN_POINT('',(0.,-4.38000000001296,-216.666666666689));
#2325=DIRECTION('',(0.,1.,0.));
#2326=DIRECTION('',(0.,0.,1.));
#2327=AXIS2_PLACEMENT_3D('',#2324,#2325,#2326);
#2328=CYLINDRICAL_SURFACE('',#2327,5.00000000000032);
#2329=CARTESIAN_POINT('',(0.,-12.3800000000229,-216.666666666689));
#2330=DIRECTION('',(0.,1.,0.));
#2331=DIRECTION('',(-1.,0.,0.));
#2332=AXIS2_PLACEMENT_3D('',#2329,#2330,#2331);
#2333=CIRCLE('',#2332,4.99999999999144);
#2334=CARTESIAN_POINT('',(-4.99999999999144,-12.3800000000229,-216.666666666689));
#2335=VERTEX_POINT('',#2334);
#2336=EDGE_CURVE('E1282',#2335,#2335,#2333,.T.);
#2337=ORIENTED_EDGE('',*,*,#2336,.T.);
#2338=EDGE_LOOP('',(#2337));
#2339=FACE_BOUND('',#2338,.T.);
#2340=ORIENTED_EDGE('',*,*,#722,.F.);
#2341=EDGE_LOOP('',(#2340));
#2342=FACE_BOUND('',#2341,.T.);
#2343=ADVANCED_FACE('F2146',(#2339,#2342),#2328,.F.);
#2344=CARTESIAN_POINT('',(0.,-4.38000000001296,-283.333333333216));
#2345=DIRECTION('',(0.,1.,0.));
#2346=DIRECTION('',(0.,0.,1.));
#2347=AXIS2_PLACEMENT_3D('',#2344,#2345,#2346);
#2348=CYLINDRICAL_SURFACE('',#2347,5.00000000000032);
#2349=CARTESIAN_POINT('',(0.,-12.3800000000229,-283.333333333216));
#2350=DIRECTION('',(0.,1.,0.));
#2351=DIRECTION('',(0.,0.,1.));
#2352=AXIS2_PLACEMENT_3D('',#2349,#2350,#2351);
#2353=CIRCLE('',#2352,4.99999999999146);
#2354=CARTESIAN_POINT('',(0.,-12.3800000000229,-278.333333333225));
#2355=VERTEX_POINT('',#2354);
#2356=EDGE_CURVE('E1279',#2355,#2355,#2353,.T.);
#2357=ORIENTED_EDGE('',*,*,#2356,.T.);
#2358=EDGE_LOOP('',(#2357));
#2359=FACE_BOUND('',#2358,.T.);
#2360=ORIENTED_EDGE('',*,*,#743,.F.);
#2361=EDGE_LOOP('',(#2360));
#2362=FACE_BOUND('',#2361,.T.);
#2363=ADVANCED_FACE('F2142',(#2359,#2362),#2348,.F.);
#2364=CARTESIAN_POINT('',(0.,-4.38000000001296,-316.66666666667));
#2365=DIRECTION('',(0.,1.,0.));
#2366=DIRECTION('',(0.,0.,1.));
#2367=AXIS2_PLACEMENT_3D('',#2364,#2365,#2366);
#2368=CYLINDRICAL_SURFACE('',#2367,5.00000000000032);
#2369=CARTESIAN_POINT('',(0.,-12.3800000000229,-316.66666666667));
#2370=DIRECTION('',(0.,1.,0.));
#2371=DIRECTION('',(0.,0.,1.));
#2372=AXIS2_PLACEMENT_3D('',#2369,#2370,#2371);
#2373=CIRCLE('',#2372,4.99999999999146);
#2374=CARTESIAN_POINT('',(0.,-12.3800000000229,-311.666666666679));
#2375=VERTEX_POINT('',#2374);
#2376=EDGE_CURVE('E1052',#2375,#2375,#2373,.T.);
#2377=ORIENTED_EDGE('',*,*,#2376,.T.);
#2378=EDGE_LOOP('',(#2377));
#2379=FACE_BOUND('',#2378,.T.);
#2380=ORIENTED_EDGE('',*,*,#764,.F.);
#2381=EDGE_LOOP('',(#2380));
#2382=FACE_BOUND('',#2381,.T.);
#2383=ADVANCED_FACE('F2139',(#2379,#2382),#2368,.F.);
#2384=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-545.000000000106));
#2385=DIRECTION('',(-1.,0.,0.));
#2386=DIRECTION('',(0.,0.,1.));
#2387=AXIS2_PLACEMENT_3D('',#2384,#2385,#2386);
#2388=PLANE('',#2387);
#2389=ORIENTED_EDGE('',*,*,#1172,.F.);
#2390=DIRECTION('',(0.,0.,-1.));
#2391=VECTOR('',#2390,1.);
#2392=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-594.999999999906));
#2393=LINE('',#2392,#2391);
#2394=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-594.999999999906));
#2395=VERTEX_POINT('',#2394);
#2396=EDGE_CURVE('E726',#2395,#1163,#2393,.F.);
#2397=ORIENTED_EDGE('',*,*,#2396,.F.);
#2398=DIRECTION('',(0.,1.,0.));
#2399=VECTOR('',#2398,1.);
#2400=CARTESIAN_POINT('',(-8.00000000000102,-35.0000000000124,-594.999999999906));
#2401=LINE('',#2400,#2399);
#2402=CARTESIAN_POINT('',(-8.00000000000102,-30.000000000007,-594.999999999906));
#2403=VERTEX_POINT('',#2402);
#2404=EDGE_CURVE('E1051',#2395,#2403,#2401,.T.);
#2405=ORIENTED_EDGE('',*,*,#2404,.T.);
#2406=DIRECTION('',(0.,0.,1.));
#2407=VECTOR('',#2406,1.);
#2408=CARTESIAN_POINT('',(-8.00000000000102,-30.000000000007,-545.000000000106));
#2409=LINE('',#2408,#2407);
#2410=EDGE_CURVE('E759',#2403,#1171,#2409,.T.);
#2411=ORIENTED_EDGE('',*,*,#2410,.T.);
#2412=EDGE_LOOP('',(#2389,#2397,#2405,#2411));
#2413=FACE_BOUND('',#2412,.T.);
#2414=ADVANCED_FACE('F1657',(#2413),#2388,.F.);
#2415=CARTESIAN_POINT('',(8.00000000000102,-30.000000000007,-545.000000000106));
#2416=DIRECTION('',(0.,1.,0.));
#2417=DIRECTION('',(0.,0.,1.));
#2418=AXIS2_PLACEMENT_3D('',#2415,#2416,#2417);
#2419=PLANE('',#2418);
#2420=ORIENTED_EDGE('',*,*,#914,.F.);
#2421=EDGE_LOOP('',(#2420));
#2422=FACE_BOUND('',#2421,.T.);
#2423=ORIENTED_EDGE('',*,*,#1181,.F.);
#2424=ORIENTED_EDGE('',*,*,#2410,.F.);
#2425=DIRECTION('',(1.,0.,0.));
#2426=VECTOR('',#2425,1.);
#2427=CARTESIAN_POINT('',(-84.9999999999902,-30.000000000007,-594.999999999906));
#2428=LINE('',#2427,#2426);
#2429=CARTESIAN_POINT('',(8.00000000000102,-30.000000000007,-594.999999999906));
#2430=VERTEX_POINT('',#2429);
#2431=EDGE_CURVE('E1440',#2403,#2430,#2428,.T.);
#2432=ORIENTED_EDGE('',*,*,#2431,.T.);
#2433=DIRECTION('',(0.,0.,-1.));
#2434=VECTOR('',#2433,1.);
#2435=CARTESIAN_POINT('',(8.00000000000102,-30.000000000007,-545.000000000106));
#2436=LINE('',#2435,#2434);
#2437=EDGE_CURVE('E756',#2430,#1180,#2436,.F.);
#2438=ORIENTED_EDGE('',*,*,#2437,.T.);
#2439=EDGE_LOOP('',(#2423,#2424,#2432,#2438));
#2440=FACE_BOUND('',#2439,.T.);
#2441=ADVANCED_FACE('F1660',(#2422,#2440),#2419,.F.);
#2442=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-545.000000000106));
#2443=DIRECTION('',(1.,0.,0.));
#2444=DIRECTION('',(0.,0.,-1.));
#2445=AXIS2_PLACEMENT_3D('',#2442,#2443,#2444);
#2446=PLANE('',#2445);
#2447=ORIENTED_EDGE('',*,*,#1189,.F.);
#2448=ORIENTED_EDGE('',*,*,#2437,.F.);
#2449=DIRECTION('',(0.,1.,0.));
#2450=VECTOR('',#2449,1.);
#2451=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-594.999999999906));
#2452=LINE('',#2451,#2450);
#2453=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-594.999999999906));
#2454=VERTEX_POINT('',#2453);
#2455=EDGE_CURVE('E1515',#2430,#2454,#2452,.F.);
#2456=ORIENTED_EDGE('',*,*,#2455,.T.);
#2457=DIRECTION('',(0.,0.,-1.));
#2458=VECTOR('',#2457,1.);
#2459=CARTESIAN_POINT('',(8.00000000000102,-35.0000000000124,-594.999999999906));
#2460=LINE('',#2459,#2458);
#2461=EDGE_CURVE('E751',#1188,#2454,#2460,.T.);
#2462=ORIENTED_EDGE('',*,*,#2461,.F.);
#2463=EDGE_LOOP('',(#2447,#2448,#2456,#2462));
#2464=FACE_BOUND('',#2463,.T.);
#2465=ADVANCED_FACE('F1662',(#2464),#2446,.F.);
#2466=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2467=DIRECTION('',(0.,-1.,0.));
#2468=DIRECTION('',(0.,0.,-1.));
#2469=AXIS2_PLACEMENT_3D('',#2466,#2467,#2468);
#2470=PLANE('',#2469);
#2471=ORIENTED_EDGE('',*,*,#1196,.T.);
#2472=ORIENTED_EDGE('',*,*,#2461,.T.);
#2473=DIRECTION('',(1.,0.,0.));
#2474=VECTOR('',#2473,1.);
#2475=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2476=LINE('',#2475,#2474);
#2477=EDGE_CURVE('E1506',#2454,#973,#2476,.T.);
#2478=ORIENTED_EDGE('',*,*,#2477,.T.);
#2479=ORIENTED_EDGE('',*,*,#974,.T.);
#2480=ORIENTED_EDGE('',*,*,#1019,.T.);
#2481=ORIENTED_EDGE('',*,*,#948,.T.);
#2482=EDGE_LOOP('',(#2471,#2472,#2478,#2479,#2480,#2481));
#2483=FACE_BOUND('',#2482,.T.);
#2484=ADVANCED_FACE('F1668',(#2483),#2470,.T.);
#2485=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-594.999999999906));
#2486=DIRECTION('',(0.,1.,0.));
#2487=DIRECTION('',(0.,0.,1.));
#2488=AXIS2_PLACEMENT_3D('',#2485,#2486,#2487);
#2489=PLANE('',#2488);
#2490=ORIENTED_EDGE('',*,*,#1037,.F.);
#2491=ORIENTED_EDGE('',*,*,#1756,.F.);
#2492=ORIENTED_EDGE('',*,*,#1516,.F.);
#2493=ORIENTED_EDGE('',*,*,#1005,.F.);
#2494=ORIENTED_EDGE('',*,*,#988,.F.);
#2495=DIRECTION('',(1.,0.,0.));
#2496=VECTOR('',#2495,1.);
#2497=CARTESIAN_POINT('',(-84.9999999999902,-33.999999999991,-594.999999999906));
#2498=LINE('',#2497,#2496);
#2499=EDGE_CURVE('E1048',#981,#1036,#2498,.T.);
#2500=ORIENTED_EDGE('',*,*,#2499,.T.);
#2501=EDGE_LOOP('',(#2490,#2491,#2492,#2493,#2494,#2500));
#2502=FACE_BOUND('',#2501,.T.);
#2503=ADVANCED_FACE('F1685',(#2502),#2489,.F.);
#2504=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2505=DIRECTION('',(0.,-1.,0.));
#2506=DIRECTION('',(0.,0.,-1.));
#2507=AXIS2_PLACEMENT_3D('',#2504,#2505,#2506);
#2508=PLANE('',#2507);
#2509=DIRECTION('',(0.,0.,-1.));
#2510=VECTOR('',#2509,1.);
#2511=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-594.999999999906));
#2512=LINE('',#2511,#2510);
#2513=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-594.999999999906));
#2514=VERTEX_POINT('',#2513);
#2515=EDGE_CURVE('E1193',#1741,#2514,#2512,.T.);
#2516=ORIENTED_EDGE('',*,*,#2515,.F.);
#2517=ORIENTED_EDGE('',*,*,#1742,.T.);
#2518=ORIENTED_EDGE('',*,*,#1053,.T.);
#2519=DIRECTION('',(1.,0.,0.));
#2520=VECTOR('',#2519,1.);
#2521=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2522=LINE('',#2521,#2520);
#2523=EDGE_CURVE('E1045',#1044,#2514,#2522,.T.);
#2524=ORIENTED_EDGE('',*,*,#2523,.T.);
#2525=EDGE_LOOP('',(#2516,#2517,#2518,#2524));
#2526=FACE_BOUND('',#2525,.T.);
#2527=ADVANCED_FACE('F2123',(#2526),#2508,.T.);
#2528=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#2529=DIRECTION('',(0.,1.,0.));
#2530=DIRECTION('',(0.,0.,1.));
#2531=AXIS2_PLACEMENT_3D('',#2528,#2529,#2530);
#2532=PLANE('',#2531);
#2533=ORIENTED_EDGE('',*,*,#1076,.T.);
#2534=EDGE_LOOP('',(#2533));
#2535=FACE_BOUND('',#2534,.T.);
#2536=DIRECTION('',(0.,0.,-1.));
#2537=VECTOR('',#2536,1.);
#2538=CARTESIAN_POINT('',(30.500000000005,35.0000000000124,-594.999999999906));
#2539=LINE('',#2538,#2537);
#2540=CARTESIAN_POINT('',(30.500000000005,35.0000000000124,-594.999999999906));
#2541=VERTEX_POINT('',#2540);
#2542=EDGE_CURVE('E701',#2541,#1791,#2539,.F.);
#2543=ORIENTED_EDGE('',*,*,#2542,.T.);
#2544=ORIENTED_EDGE('',*,*,#1816,.T.);
#2545=DIRECTION('',(0.,0.,-1.));
#2546=VECTOR('',#2545,1.);
#2547=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-594.999999999906));
#2548=LINE('',#2547,#2546);
#2549=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-594.999999999906));
#2550=VERTEX_POINT('',#2549);
#2551=EDGE_CURVE('E1182',#2550,#1809,#2548,.F.);
#2552=ORIENTED_EDGE('',*,*,#2551,.F.);
#2553=DIRECTION('',(1.,0.,0.));
#2554=VECTOR('',#2553,1.);
#2555=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#2556=LINE('',#2555,#2554);
#2557=EDGE_CURVE('E1027',#2550,#2541,#2556,.F.);
#2558=ORIENTED_EDGE('',*,*,#2557,.T.);
#2559=EDGE_LOOP('',(#2543,#2544,#2552,#2558));
#2560=FACE_BOUND('',#2559,.T.);
#2561=ADVANCED_FACE('F1919',(#2535,#2560),#2532,.T.);
#2562=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#2563=DIRECTION('',(0.,1.,0.));
#2564=DIRECTION('',(0.,0.,1.));
#2565=AXIS2_PLACEMENT_3D('',#2562,#2563,#2564);
#2566=PLANE('',#2565);
#2567=ORIENTED_EDGE('',*,*,#1096,.T.);
#2568=EDGE_LOOP('',(#2567));
#2569=FACE_BOUND('',#2568,.T.);
#2570=DIRECTION('',(0.,0.,1.));
#2571=VECTOR('',#2570,1.);
#2572=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#2573=LINE('',#2572,#2571);
#2574=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#2575=VERTEX_POINT('',#2574);
#2576=EDGE_CURVE('E1097',#1992,#2575,#2573,.F.);
#2577=ORIENTED_EDGE('',*,*,#2576,.F.);
#2578=ORIENTED_EDGE('',*,*,#1993,.T.);
#2579=DIRECTION('',(0.,0.,1.));
#2580=VECTOR('',#2579,1.);
#2581=CARTESIAN_POINT('',(-30.500000000005,35.0000000000124,-594.999999999906));
#2582=LINE('',#2581,#2580);
#2583=CARTESIAN_POINT('',(-30.500000000005,35.0000000000124,-594.999999999906));
#2584=VERTEX_POINT('',#2583);
#2585=EDGE_CURVE('E1114',#1984,#2584,#2582,.F.);
#2586=ORIENTED_EDGE('',*,*,#2585,.T.);
#2587=DIRECTION('',(1.,0.,0.));
#2588=VECTOR('',#2587,1.);
#2589=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#2590=LINE('',#2589,#2588);
#2591=EDGE_CURVE('E980',#2584,#2575,#2590,.F.);
#2592=ORIENTED_EDGE('',*,*,#2591,.T.);
#2593=EDGE_LOOP('',(#2577,#2578,#2586,#2592));
#2594=FACE_BOUND('',#2593,.T.);
#2595=ADVANCED_FACE('F1828',(#2569,#2594),#2566,.T.);
#2596=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2597=DIRECTION('',(0.,-1.,0.));
#2598=DIRECTION('',(0.,0.,-1.));
#2599=AXIS2_PLACEMENT_3D('',#2596,#2597,#2598);
#2600=PLANE('',#2599);
#2601=ORIENTED_EDGE('',*,*,#1117,.T.);
#2602=ORIENTED_EDGE('',*,*,#2024,.T.);
#2603=DIRECTION('',(0.,0.,1.));
#2604=VECTOR('',#2603,1.);
#2605=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2606=LINE('',#2605,#2604);
#2607=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2608=VERTEX_POINT('',#2607);
#2609=EDGE_CURVE('E1085',#2608,#2015,#2606,.T.);
#2610=ORIENTED_EDGE('',*,*,#2609,.F.);
#2611=DIRECTION('',(1.,0.,0.));
#2612=VECTOR('',#2611,1.);
#2613=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2614=LINE('',#2613,#2612);
#2615=EDGE_CURVE('E962',#2608,#1114,#2614,.T.);
#2616=ORIENTED_EDGE('',*,*,#2615,.T.);
#2617=EDGE_LOOP('',(#2601,#2602,#2610,#2616));
#2618=FACE_BOUND('',#2617,.T.);
#2619=ADVANCED_FACE('F1799',(#2618),#2600,.T.);
#2620=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-594.999999999906));
#2621=DIRECTION('',(0.,1.,0.));
#2622=DIRECTION('',(0.,0.,1.));
#2623=AXIS2_PLACEMENT_3D('',#2620,#2621,#2622);
#2624=PLANE('',#2623);
#2625=DIRECTION('',(1.,0.,0.));
#2626=VECTOR('',#2625,1.);
#2627=CARTESIAN_POINT('',(-84.9999999999902,-33.999999999991,-594.999999999906));
#2628=LINE('',#2627,#2626);
#2629=EDGE_CURVE('E959',#1124,#1278,#2628,.T.);
#2630=ORIENTED_EDGE('',*,*,#2629,.T.);
#2631=ORIENTED_EDGE('',*,*,#1279,.F.);
#2632=ORIENTED_EDGE('',*,*,#1262,.F.);
#2633=ORIENTED_EDGE('',*,*,#2227,.F.);
#2634=ORIENTED_EDGE('',*,*,#2033,.F.);
#2635=ORIENTED_EDGE('',*,*,#1133,.F.);
#2636=EDGE_LOOP('',(#2630,#2631,#2632,#2633,#2634,#2635));
#2637=FACE_BOUND('',#2636,.T.);
#2638=ADVANCED_FACE('F1786',(#2637),#2624,.F.);
#2639=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2640=DIRECTION('',(0.,-1.,0.));
#2641=DIRECTION('',(0.,0.,-1.));
#2642=AXIS2_PLACEMENT_3D('',#2639,#2640,#2641);
#2643=PLANE('',#2642);
#2644=DIRECTION('',(1.,0.,0.));
#2645=VECTOR('',#2644,1.);
#2646=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2647=LINE('',#2646,#2645);
#2648=EDGE_CURVE('E958',#1286,#2395,#2647,.T.);
#2649=ORIENTED_EDGE('',*,*,#2648,.T.);
#2650=ORIENTED_EDGE('',*,*,#2396,.T.);
#2651=ORIENTED_EDGE('',*,*,#1164,.T.);
#2652=ORIENTED_EDGE('',*,*,#1220,.T.);
#2653=ORIENTED_EDGE('',*,*,#1246,.T.);
#2654=ORIENTED_EDGE('',*,*,#1293,.T.);
#2655=EDGE_LOOP('',(#2649,#2650,#2651,#2652,#2653,#2654));
#2656=FACE_BOUND('',#2655,.T.);
#2657=ADVANCED_FACE('F1647',(#2656),#2643,.T.);
#2658=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2659=DIRECTION('',(0.,-1.,0.));
#2660=DIRECTION('',(0.,0.,-1.));
#2661=AXIS2_PLACEMENT_3D('',#2658,#2659,#2660);
#2662=PLANE('',#2661);
#2663=ORIENTED_EDGE('',*,*,#2200,.T.);
#2664=ORIENTED_EDGE('',*,*,#1355,.T.);
#2665=ORIENTED_EDGE('',*,*,#1471,.T.);
#2666=ORIENTED_EDGE('',*,*,#1317,.T.);
#2667=ORIENTED_EDGE('',*,*,#1413,.T.);
#2668=DIRECTION('',(0.,0.,1.));
#2669=VECTOR('',#2668,1.);
#2670=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,-292.666666666766));
#2671=LINE('',#2670,#2669);
#2672=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,0.));
#2673=VERTEX_POINT('',#2672);
#2674=EDGE_CURVE('E1222',#1405,#2673,#2671,.T.);
#2675=ORIENTED_EDGE('',*,*,#2674,.T.);
#2676=DIRECTION('',(1.,0.,0.));
#2677=VECTOR('',#2676,1.);
#2678=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#2679=LINE('',#2678,#2677);
#2680=EDGE_CURVE('E954',#2154,#2673,#2679,.T.);
#2681=ORIENTED_EDGE('',*,*,#2680,.F.);
#2682=ORIENTED_EDGE('',*,*,#2155,.T.);
#2683=EDGE_LOOP('',(#2663,#2664,#2665,#2666,#2667,#2675,#2681,#2682));
#2684=FACE_BOUND('',#2683,.T.);
#2685=ADVANCED_FACE('F1748',(#2684),#2662,.T.);
#2686=CARTESIAN_POINT('',(-10.0000000000006,-29.500000000009,-292.666666666766));
#2687=DIRECTION('',(-1.,0.,0.));
#2688=DIRECTION('',(0.,0.,1.));
#2689=AXIS2_PLACEMENT_3D('',#2686,#2687,#2688);
#2690=PLANE('',#2689);
#2691=ORIENTED_EDGE('',*,*,#1406,.F.);
#2692=DIRECTION('',(0.,0.,-1.));
#2693=VECTOR('',#2692,1.);
#2694=CARTESIAN_POINT('',(-10.0000000000006,-29.500000000009,-292.666666666766));
#2695=LINE('',#2694,#2693);
#2696=CARTESIAN_POINT('',(-10.0000000000006,-29.500000000009,0.));
#2697=VERTEX_POINT('',#2696);
#2698=EDGE_CURVE('E718',#2697,#1397,#2695,.T.);
#2699=ORIENTED_EDGE('',*,*,#2698,.F.);
#2700=DIRECTION('',(0.,1.,0.));
#2701=VECTOR('',#2700,1.);
#2702=CARTESIAN_POINT('',(-10.0000000000006,-35.0000000000124,0.));
#2703=LINE('',#2702,#2701);
#2704=EDGE_CURVE('E1402',#2673,#2697,#2703,.T.);
#2705=ORIENTED_EDGE('',*,*,#2704,.F.);
#2706=ORIENTED_EDGE('',*,*,#2674,.F.);
#2707=EDGE_LOOP('',(#2691,#2699,#2705,#2706));
#2708=FACE_BOUND('',#2707,.T.);
#2709=ADVANCED_FACE('F2105',(#2708),#2690,.F.);
#2710=CARTESIAN_POINT('',(0.,-29.500000000009,-292.666666666766));
#2711=DIRECTION('',(0.,-1.,0.));
#2712=DIRECTION('',(0.,0.,-1.));
#2713=AXIS2_PLACEMENT_3D('',#2710,#2711,#2712);
#2714=PLANE('',#2713);
#2715=CARTESIAN_POINT('',(0.,-29.500000000009,-149.999999999906));
#2716=DIRECTION('',(0.,-1.,0.));
#2717=DIRECTION('',(0.,0.,-1.));
#2718=AXIS2_PLACEMENT_3D('',#2715,#2716,#2717);
#2719=CIRCLE('',#2718,8.00000000000001);
#2720=CARTESIAN_POINT('',(0.,-29.500000000009,-157.999999999906));
#2721=VERTEX_POINT('',#2720);
#2722=EDGE_CURVE('E849',#2721,#2721,#2719,.T.);
#2723=ORIENTED_EDGE('',*,*,#2722,.F.);
#2724=EDGE_LOOP('',(#2723));
#2725=FACE_BOUND('',#2724,.T.);
#2726=CARTESIAN_POINT('',(0.,-29.500000000009,-249.999999999906));
#2727=DIRECTION('',(0.,-1.,0.));
#2728=DIRECTION('',(0.,0.,-1.));
#2729=AXIS2_PLACEMENT_3D('',#2726,#2727,#2728);
#2730=CIRCLE('',#2729,8.50000000000001);
#2731=CARTESIAN_POINT('',(0.,-29.500000000009,-258.499999999906));
#2732=VERTEX_POINT('',#2731);
#2733=EDGE_CURVE('E671',#2732,#2732,#2730,.T.);
#2734=ORIENTED_EDGE('',*,*,#2733,.F.);
#2735=EDGE_LOOP('',(#2734));
#2736=FACE_BOUND('',#2735,.T.);
#2737=DIRECTION('',(0.,0.,-1.));
#2738=VECTOR('',#2737,1.);
#2739=CARTESIAN_POINT('',(10.0000000000006,-29.500000000009,-292.666666666766));
#2740=LINE('',#2739,#2738);
#2741=CARTESIAN_POINT('',(10.0000000000006,-29.500000000009,0.));
#2742=VERTEX_POINT('',#2741);
#2743=EDGE_CURVE('E1218',#1388,#2742,#2740,.F.);
#2744=ORIENTED_EDGE('',*,*,#2743,.T.);
#2745=DIRECTION('',(1.,0.,0.));
#2746=VECTOR('',#2745,1.);
#2747=CARTESIAN_POINT('',(-84.9999999999902,-29.500000000009,0.));
#2748=LINE('',#2747,#2746);
#2749=EDGE_CURVE('E1390',#2697,#2742,#2748,.T.);
#2750=ORIENTED_EDGE('',*,*,#2749,.F.);
#2751=ORIENTED_EDGE('',*,*,#2698,.T.);
#2752=ORIENTED_EDGE('',*,*,#1398,.T.);
#2753=EDGE_LOOP('',(#2744,#2750,#2751,#2752));
#2754=FACE_BOUND('',#2753,.T.);
#2755=ADVANCED_FACE('F2101',(#2725,#2736,#2754),#2714,.T.);
#2756=CARTESIAN_POINT('',(10.0000000000006,-29.500000000009,-292.666666666766));
#2757=DIRECTION('',(1.,0.,0.));
#2758=DIRECTION('',(0.,0.,-1.));
#2759=AXIS2_PLACEMENT_3D('',#2756,#2757,#2758);
#2760=PLANE('',#2759);
#2761=DIRECTION('',(0.,1.,0.));
#2762=VECTOR('',#2761,1.);
#2763=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,0.));
#2764=LINE('',#2763,#2762);
#2765=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,0.));
#2766=VERTEX_POINT('',#2765);
#2767=EDGE_CURVE('E1388',#2742,#2766,#2764,.F.);
#2768=ORIENTED_EDGE('',*,*,#2767,.F.);
#2769=ORIENTED_EDGE('',*,*,#2743,.F.);
#2770=ORIENTED_EDGE('',*,*,#1389,.F.);
#2771=DIRECTION('',(0.,0.,-1.));
#2772=VECTOR('',#2771,1.);
#2773=CARTESIAN_POINT('',(10.0000000000006,-35.0000000000124,-594.999999999906));
#2774=LINE('',#2773,#2772);
#2775=EDGE_CURVE('E714',#2766,#1380,#2774,.T.);
#2776=ORIENTED_EDGE('',*,*,#2775,.F.);
#2777=EDGE_LOOP('',(#2768,#2769,#2770,#2776));
#2778=FACE_BOUND('',#2777,.T.);
#2779=ADVANCED_FACE('F2098',(#2778),#2760,.F.);
#2780=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2781=DIRECTION('',(0.,-1.,0.));
#2782=DIRECTION('',(0.,0.,-1.));
#2783=AXIS2_PLACEMENT_3D('',#2780,#2781,#2782);
#2784=PLANE('',#2783);
#2785=ORIENTED_EDGE('',*,*,#1580,.T.);
#2786=ORIENTED_EDGE('',*,*,#1620,.T.);
#2787=DIRECTION('',(1.,0.,0.));
#2788=VECTOR('',#2787,1.);
#2789=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#2790=LINE('',#2789,#2788);
#2791=EDGE_CURVE('E1368',#2766,#1613,#2790,.T.);
#2792=ORIENTED_EDGE('',*,*,#2791,.F.);
#2793=ORIENTED_EDGE('',*,*,#2775,.T.);
#2794=ORIENTED_EDGE('',*,*,#1381,.T.);
#2795=ORIENTED_EDGE('',*,*,#1438,.T.);
#2796=ORIENTED_EDGE('',*,*,#1461,.T.);
#2797=ORIENTED_EDGE('',*,*,#1495,.T.);
#2798=EDGE_LOOP('',(#2785,#2786,#2792,#2793,#2794,#2795,#2796,#2797));
#2799=FACE_BOUND('',#2798,.T.);
#2800=ADVANCED_FACE('F1735',(#2799),#2784,.T.);
#2801=CARTESIAN_POINT('',(41.5000000000118,-33.999999999991,-594.999999999906));
#2802=DIRECTION('',(0.,1.,0.));
#2803=DIRECTION('',(0.,0.,1.));
#2804=AXIS2_PLACEMENT_3D('',#2801,#2802,#2803);
#2805=PLANE('',#2804);
#2806=ORIENTED_EDGE('',*,*,#1606,.F.);
#2807=ORIENTED_EDGE('',*,*,#1589,.F.);
#2808=ORIENTED_EDGE('',*,*,#1550,.F.);
#2809=ORIENTED_EDGE('',*,*,#1691,.F.);
#2810=ORIENTED_EDGE('',*,*,#1654,.F.);
#2811=DIRECTION('',(1.,0.,0.));
#2812=VECTOR('',#2811,1.);
#2813=CARTESIAN_POINT('',(-84.9999999999902,-33.999999999991,0.));
#2814=LINE('',#2813,#2812);
#2815=EDGE_CURVE('E1365',#1605,#1645,#2814,.T.);
#2816=ORIENTED_EDGE('',*,*,#2815,.F.);
#2817=EDGE_LOOP('',(#2806,#2807,#2808,#2809,#2810,#2816));
#2818=FACE_BOUND('',#2817,.T.);
#2819=ADVANCED_FACE('F1707',(#2818),#2805,.F.);
#2820=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#2821=DIRECTION('',(0.,-1.,0.));
#2822=DIRECTION('',(0.,0.,-1.));
#2823=AXIS2_PLACEMENT_3D('',#2820,#2821,#2822);
#2824=PLANE('',#2823);
#2825=ORIENTED_EDGE('',*,*,#1638,.T.);
#2826=ORIENTED_EDGE('',*,*,#1684,.T.);
#2827=DIRECTION('',(0.,0.,-1.));
#2828=VECTOR('',#2827,1.);
#2829=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-594.999999999906));
#2830=LINE('',#2829,#2828);
#2831=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,0.));
#2832=VERTEX_POINT('',#2831);
#2833=EDGE_CURVE('E1196',#2832,#1675,#2830,.T.);
#2834=ORIENTED_EDGE('',*,*,#2833,.F.);
#2835=DIRECTION('',(1.,0.,0.));
#2836=VECTOR('',#2835,1.);
#2837=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#2838=LINE('',#2837,#2836);
#2839=EDGE_CURVE('E950',#1635,#2832,#2838,.T.);
#2840=ORIENTED_EDGE('',*,*,#2839,.F.);
#2841=EDGE_LOOP('',(#2825,#2826,#2834,#2840));
#2842=FACE_BOUND('',#2841,.T.);
#2843=ADVANCED_FACE('F2089',(#2842),#2824,.T.);
#2844=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-594.999999999906));
#2845=DIRECTION('',(1.,0.,0.));
#2846=DIRECTION('',(0.,0.,-1.));
#2847=AXIS2_PLACEMENT_3D('',#2844,#2845,#2846);
#2848=PLANE('',#2847);
#2849=DIRECTION('',(0.,0.,1.));
#2850=VECTOR('',#2849,1.);
#2851=CARTESIAN_POINT('',(84.9999999999902,-8.99999999999956,-594.999999999906));
#2852=LINE('',#2851,#2850);
#2853=CARTESIAN_POINT('',(84.9999999999902,-8.99999999999956,0.));
#2854=VERTEX_POINT('',#2853);
#2855=CARTESIAN_POINT('',(84.9999999999902,-8.99999999999956,-594.999999999906));
#2856=VERTEX_POINT('',#2855);
#2857=EDGE_CURVE('E1191',#2854,#2856,#2852,.F.);
#2858=ORIENTED_EDGE('',*,*,#2857,.F.);
#2859=DIRECTION('',(0.,1.,0.));
#2860=VECTOR('',#2859,1.);
#2861=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,0.));
#2862=LINE('',#2861,#2860);
#2863=EDGE_CURVE('E948',#2832,#2854,#2862,.T.);
#2864=ORIENTED_EDGE('',*,*,#2863,.F.);
#2865=ORIENTED_EDGE('',*,*,#2833,.T.);
#2866=ORIENTED_EDGE('',*,*,#1678,.T.);
#2867=ORIENTED_EDGE('',*,*,#1724,.T.);
#2868=ORIENTED_EDGE('',*,*,#1748,.T.);
#2869=ORIENTED_EDGE('',*,*,#2515,.T.);
#2870=DIRECTION('',(0.,1.,0.));
#2871=VECTOR('',#2870,1.);
#2872=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-594.999999999906));
#2873=LINE('',#2872,#2871);
#2874=EDGE_CURVE('E1042',#2514,#2856,#2873,.T.);
#2875=ORIENTED_EDGE('',*,*,#2874,.T.);
#2876=EDGE_LOOP('',(#2858,#2864,#2865,#2866,#2867,#2868,#2869,#2875));
#2877=FACE_BOUND('',#2876,.T.);
#2878=ADVANCED_FACE('F2085',(#2877),#2848,.T.);
#2879=CARTESIAN_POINT('',(84.9999999999902,-8.99999999999956,-594.999999999906));
#2880=DIRECTION('',(0.,1.,0.));
#2881=DIRECTION('',(0.,0.,1.));
#2882=AXIS2_PLACEMENT_3D('',#2879,#2880,#2881);
#2883=PLANE('',#2882);
#2884=DIRECTION('',(1.,0.,0.));
#2885=VECTOR('',#2884,1.);
#2886=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,0.));
#2887=LINE('',#2886,#2885);
#2888=CARTESIAN_POINT('',(75.0000000000048,-8.99999999999956,0.));
#2889=VERTEX_POINT('',#2888);
#2890=EDGE_CURVE('E946',#2854,#2889,#2887,.F.);
#2891=ORIENTED_EDGE('',*,*,#2890,.F.);
#2892=ORIENTED_EDGE('',*,*,#2857,.T.);
#2893=DIRECTION('',(1.,0.,0.));
#2894=VECTOR('',#2893,1.);
#2895=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,-594.999999999906));
#2896=LINE('',#2895,#2894);
#2897=CARTESIAN_POINT('',(75.0000000000048,-8.99999999999956,-594.999999999906));
#2898=VERTEX_POINT('',#2897);
#2899=EDGE_CURVE('E1039',#2856,#2898,#2896,.F.);
#2900=ORIENTED_EDGE('',*,*,#2899,.T.);
#2901=DIRECTION('',(0.,0.,-1.));
#2902=VECTOR('',#2901,1.);
#2903=CARTESIAN_POINT('',(75.0000000000048,-8.99999999999956,-594.999999999906));
#2904=LINE('',#2903,#2902);
#2905=EDGE_CURVE('E1189',#2889,#2898,#2904,.T.);
#2906=ORIENTED_EDGE('',*,*,#2905,.F.);
#2907=EDGE_LOOP('',(#2891,#2892,#2900,#2906));
#2908=FACE_BOUND('',#2907,.T.);
#2909=ADVANCED_FACE('F2081',(#2908),#2883,.T.);
#2910=CARTESIAN_POINT('',(75.0000000000048,8.49999999999902,-594.999999999906));
#2911=DIRECTION('',(1.,0.,0.));
#2912=DIRECTION('',(0.,0.,-1.));
#2913=AXIS2_PLACEMENT_3D('',#2910,#2911,#2912);
#2914=PLANE('',#2913);
#2915=DIRECTION('',(0.,1.,0.));
#2916=VECTOR('',#2915,1.);
#2917=CARTESIAN_POINT('',(75.0000000000048,-35.0000000000124,0.));
#2918=LINE('',#2917,#2916);
#2919=CARTESIAN_POINT('',(75.0000000000048,8.49999999999902,0.));
#2920=VERTEX_POINT('',#2919);
#2921=EDGE_CURVE('E944',#2889,#2920,#2918,.T.);
#2922=ORIENTED_EDGE('',*,*,#2921,.F.);
#2923=ORIENTED_EDGE('',*,*,#2905,.T.);
#2924=DIRECTION('',(0.,1.,0.));
#2925=VECTOR('',#2924,1.);
#2926=CARTESIAN_POINT('',(75.0000000000048,-35.0000000000124,-594.999999999906));
#2927=LINE('',#2926,#2925);
#2928=CARTESIAN_POINT('',(75.0000000000048,8.49999999999902,-594.999999999906));
#2929=VERTEX_POINT('',#2928);
#2930=EDGE_CURVE('E1036',#2898,#2929,#2927,.T.);
#2931=ORIENTED_EDGE('',*,*,#2930,.T.);
#2932=DIRECTION('',(0.,0.,-1.));
#2933=VECTOR('',#2932,1.);
#2934=CARTESIAN_POINT('',(75.0000000000048,8.49999999999902,-594.999999999906));
#2935=LINE('',#2934,#2933);
#2936=EDGE_CURVE('E1187',#2920,#2929,#2935,.T.);
#2937=ORIENTED_EDGE('',*,*,#2936,.F.);
#2938=EDGE_LOOP('',(#2922,#2923,#2931,#2937));
#2939=FACE_BOUND('',#2938,.T.);
#2940=ADVANCED_FACE('F2077',(#2939),#2914,.T.);
#2941=CARTESIAN_POINT('',(84.9999999999902,8.49999999999902,-594.999999999906));
#2942=DIRECTION('',(0.,-1.,0.));
#2943=DIRECTION('',(0.,0.,-1.));
#2944=AXIS2_PLACEMENT_3D('',#2941,#2942,#2943);
#2945=PLANE('',#2944);
#2946=DIRECTION('',(1.,0.,0.));
#2947=VECTOR('',#2946,1.);
#2948=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,0.));
#2949=LINE('',#2948,#2947);
#2950=CARTESIAN_POINT('',(84.9999999999902,8.49999999999902,0.));
#2951=VERTEX_POINT('',#2950);
#2952=EDGE_CURVE('E942',#2920,#2951,#2949,.T.);
#2953=ORIENTED_EDGE('',*,*,#2952,.F.);
#2954=ORIENTED_EDGE('',*,*,#2936,.T.);
#2955=DIRECTION('',(1.,0.,0.));
#2956=VECTOR('',#2955,1.);
#2957=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,-594.999999999906));
#2958=LINE('',#2957,#2956);
#2959=CARTESIAN_POINT('',(84.9999999999902,8.49999999999902,-594.999999999906));
#2960=VERTEX_POINT('',#2959);
#2961=EDGE_CURVE('E1033',#2929,#2960,#2958,.T.);
#2962=ORIENTED_EDGE('',*,*,#2961,.T.);
#2963=DIRECTION('',(0.,0.,-1.));
#2964=VECTOR('',#2963,1.);
#2965=CARTESIAN_POINT('',(84.9999999999902,8.49999999999902,-594.999999999906));
#2966=LINE('',#2965,#2964);
#2967=EDGE_CURVE('E1185',#2951,#2960,#2966,.T.);
#2968=ORIENTED_EDGE('',*,*,#2967,.F.);
#2969=EDGE_LOOP('',(#2953,#2954,#2962,#2968));
#2970=FACE_BOUND('',#2969,.T.);
#2971=ADVANCED_FACE('F2074',(#2970),#2945,.T.);
#2972=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-594.999999999906));
#2973=DIRECTION('',(1.,0.,0.));
#2974=DIRECTION('',(0.,0.,-1.));
#2975=AXIS2_PLACEMENT_3D('',#2972,#2973,#2974);
#2976=PLANE('',#2975);
#2977=DIRECTION('',(0.,0.,1.));
#2978=VECTOR('',#2977,1.);
#2979=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,-594.999999999906));
#2980=LINE('',#2979,#2978);
#2981=CARTESIAN_POINT('',(84.9999999999902,35.0000000000124,0.));
#2982=VERTEX_POINT('',#2981);
#2983=EDGE_CURVE('E1173',#2982,#1870,#2980,.F.);
#2984=ORIENTED_EDGE('',*,*,#2983,.F.);
#2985=DIRECTION('',(0.,1.,0.));
#2986=VECTOR('',#2985,1.);
#2987=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,0.));
#2988=LINE('',#2987,#2986);
#2989=EDGE_CURVE('E940',#2951,#2982,#2988,.T.);
#2990=ORIENTED_EDGE('',*,*,#2989,.F.);
#2991=ORIENTED_EDGE('',*,*,#2967,.T.);
#2992=DIRECTION('',(0.,1.,0.));
#2993=VECTOR('',#2992,1.);
#2994=CARTESIAN_POINT('',(84.9999999999902,-35.0000000000124,-594.999999999906));
#2995=LINE('',#2994,#2993);
#2996=EDGE_CURVE('E1030',#2960,#2550,#2995,.T.);
#2997=ORIENTED_EDGE('',*,*,#2996,.T.);
#2998=ORIENTED_EDGE('',*,*,#2551,.T.);
#2999=ORIENTED_EDGE('',*,*,#1810,.T.);
#3000=ORIENTED_EDGE('',*,*,#1846,.T.);
#3001=ORIENTED_EDGE('',*,*,#1877,.T.);
#3002=EDGE_LOOP('',(#2984,#2990,#2991,#2997,#2998,#2999,#3000,#3001));
#3003=FACE_BOUND('',#3002,.T.);
#3004=ADVANCED_FACE('F1923',(#3003),#2976,.T.);
#3005=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#3006=DIRECTION('',(0.,1.,0.));
#3007=DIRECTION('',(0.,0.,1.));
#3008=AXIS2_PLACEMENT_3D('',#3005,#3006,#3007);
#3009=PLANE('',#3008);
#3010=ORIENTED_EDGE('',*,*,#1773,.T.);
#3011=EDGE_LOOP('',(#3010));
#3012=FACE_BOUND('',#3011,.T.);
#3013=ORIENTED_EDGE('',*,*,#2983,.T.);
#3014=ORIENTED_EDGE('',*,*,#1871,.T.);
#3015=DIRECTION('',(0.,0.,-1.));
#3016=VECTOR('',#3015,1.);
#3017=CARTESIAN_POINT('',(30.500000000005,35.0000000000124,-594.999999999906));
#3018=LINE('',#3017,#3016);
#3019=CARTESIAN_POINT('',(30.500000000005,35.0000000000124,0.));
#3020=VERTEX_POINT('',#3019);
#3021=EDGE_CURVE('E1158',#1862,#3020,#3018,.F.);
#3022=ORIENTED_EDGE('',*,*,#3021,.T.);
#3023=DIRECTION('',(1.,0.,0.));
#3024=VECTOR('',#3023,1.);
#3025=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,0.));
#3026=LINE('',#3025,#3024);
#3027=EDGE_CURVE('E938',#2982,#3020,#3026,.F.);
#3028=ORIENTED_EDGE('',*,*,#3027,.F.);
#3029=EDGE_LOOP('',(#3013,#3014,#3022,#3028));
#3030=FACE_BOUND('',#3029,.T.);
#3031=ADVANCED_FACE('F1938',(#3012,#3030),#3009,.T.);
#3032=CARTESIAN_POINT('',(30.500000000005,28.4641016151424,-594.999999999906));
#3033=DIRECTION('',(1.,0.,0.));
#3034=DIRECTION('',(0.,0.,-1.));
#3035=AXIS2_PLACEMENT_3D('',#3032,#3033,#3034);
#3036=PLANE('',#3035);
#3037=ORIENTED_EDGE('',*,*,#3021,.F.);
#3038=ORIENTED_EDGE('',*,*,#1863,.F.);
#3039=ORIENTED_EDGE('',*,*,#1832,.F.);
#3040=ORIENTED_EDGE('',*,*,#1794,.F.);
#3041=ORIENTED_EDGE('',*,*,#2542,.F.);
#3042=DIRECTION('',(0.,1.,0.));
#3043=VECTOR('',#3042,1.);
#3044=CARTESIAN_POINT('',(30.500000000005,-35.0000000000124,-594.999999999906));
#3045=LINE('',#3044,#3043);
#3046=CARTESIAN_POINT('',(30.5000000000029,28.4641016151412,-594.999999999906));
#3047=VERTEX_POINT('',#3046);
#3048=EDGE_CURVE('E1024',#2541,#3047,#3045,.F.);
#3049=ORIENTED_EDGE('',*,*,#3048,.T.);
#3050=DIRECTION('',(0.,0.,1.));
#3051=VECTOR('',#3050,1.);
#3052=CARTESIAN_POINT('',(30.4999999999965,28.4641016151375,-594.999999999906));
#3053=LINE('',#3052,#3051);
#3054=CARTESIAN_POINT('',(30.5000000000029,28.4641016151412,0.));
#3055=VERTEX_POINT('',#3054);
#3056=EDGE_CURVE('E1155',#3047,#3055,#3053,.T.);
#3057=ORIENTED_EDGE('',*,*,#3056,.T.);
#3058=DIRECTION('',(0.,1.,0.));
#3059=VECTOR('',#3058,1.);
#3060=CARTESIAN_POINT('',(30.500000000005,-35.0000000000124,0.));
#3061=LINE('',#3060,#3059);
#3062=EDGE_CURVE('E936',#3020,#3055,#3061,.F.);
#3063=ORIENTED_EDGE('',*,*,#3062,.F.);
#3064=EDGE_LOOP('',(#3037,#3038,#3039,#3040,#3041,#3049,#3057,#3063));
#3065=FACE_BOUND('',#3064,.T.);
#3066=ADVANCED_FACE('F1914',(#3065),#3036,.F.);
#3067=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,-594.999999999906));
#3068=DIRECTION('',(0.866025403784429,0.500000000000017,0.));
#3069=DIRECTION('',(-0.500000000000017,0.866025403784429,0.));
#3070=AXIS2_PLACEMENT_3D('',#3067,#3068,#3069);
#3071=PLANE('',#3070);
#3072=ORIENTED_EDGE('',*,*,#3056,.F.);
#3073=DIRECTION('',(0.499999999997897,-0.866025403785653,0.));
#3074=VECTOR('',#3073,1.);
#3075=CARTESIAN_POINT('',(30.500000000005,28.4641016151424,-594.999999999906));
#3076=LINE('',#3075,#3074);
#3077=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,-594.999999999906));
#3078=VERTEX_POINT('',#3077);
#3079=EDGE_CURVE('E1021',#3047,#3078,#3076,.T.);
#3080=ORIENTED_EDGE('',*,*,#3079,.T.);
#3081=DIRECTION('',(0.,0.,1.));
#3082=VECTOR('',#3081,1.);
#3083=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,-594.999999999906));
#3084=LINE('',#3083,#3082);
#3085=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,0.));
#3086=VERTEX_POINT('',#3085);
#3087=EDGE_CURVE('E1152',#3078,#3086,#3084,.T.);
#3088=ORIENTED_EDGE('',*,*,#3087,.T.);
#3089=DIRECTION('',(0.499999999997897,-0.866025403785653,0.));
#3090=VECTOR('',#3089,1.);
#3091=CARTESIAN_POINT('',(30.500000000005,28.4641016151424,0.));
#3092=LINE('',#3091,#3090);
#3093=EDGE_CURVE('E934',#3055,#3086,#3092,.T.);
#3094=ORIENTED_EDGE('',*,*,#3093,.F.);
#3095=EDGE_LOOP('',(#3072,#3080,#3088,#3094));
#3096=FACE_BOUND('',#3095,.T.);
#3097=ADVANCED_FACE('F1909',(#3096),#3071,.F.);
#3098=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,-594.999999999906));
#3099=DIRECTION('',(0.866025403784429,-0.500000000000017,0.));
#3100=DIRECTION('',(0.500000000000017,0.866025403784429,0.));
#3101=AXIS2_PLACEMENT_3D('',#3098,#3099,#3100);
#3102=PLANE('',#3101);
#3103=ORIENTED_EDGE('',*,*,#3087,.F.);
#3104=DIRECTION('',(-0.499999999998447,-0.866025403785335,0.));
#3105=VECTOR('',#3104,1.);
#3106=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,-594.999999999906));
#3107=LINE('',#3106,#3105);
#3108=CARTESIAN_POINT('',(30.5000000000019,21.5358983848626,-594.999999999906));
#3109=VERTEX_POINT('',#3108);
#3110=EDGE_CURVE('E1018',#3078,#3109,#3107,.T.);
#3111=ORIENTED_EDGE('',*,*,#3110,.T.);
#3112=DIRECTION('',(0.,0.,-1.));
#3113=VECTOR('',#3112,1.);
#3114=CARTESIAN_POINT('',(30.500000000005,21.5358983848608,-594.999999999906));
#3115=LINE('',#3114,#3113);
#3116=CARTESIAN_POINT('',(30.5000000000019,21.5358983848626,0.));
#3117=VERTEX_POINT('',#3116);
#3118=EDGE_CURVE('E1149',#3109,#3117,#3115,.F.);
#3119=ORIENTED_EDGE('',*,*,#3118,.T.);
#3120=DIRECTION('',(-0.499999999998447,-0.866025403785335,0.));
#3121=VECTOR('',#3120,1.);
#3122=CARTESIAN_POINT('',(32.499999999997,24.9999999999991,0.));
#3123=LINE('',#3122,#3121);
#3124=EDGE_CURVE('E932',#3086,#3117,#3123,.T.);
#3125=ORIENTED_EDGE('',*,*,#3124,.F.);
#3126=EDGE_LOOP('',(#3103,#3111,#3119,#3125));
#3127=FACE_BOUND('',#3126,.T.);
#3128=ADVANCED_FACE('F1905',(#3127),#3102,.F.);
#3129=CARTESIAN_POINT('',(30.500000000005,15.000000000001,-594.999999999906));
#3130=DIRECTION('',(1.,0.,0.));
#3131=DIRECTION('',(0.,0.,-1.));
#3132=AXIS2_PLACEMENT_3D('',#3129,#3130,#3131);
#3133=PLANE('',#3132);
#3134=ORIENTED_EDGE('',*,*,#3118,.F.);
#3135=DIRECTION('',(0.,1.,0.));
#3136=VECTOR('',#3135,1.);
#3137=CARTESIAN_POINT('',(30.500000000005,-35.0000000000124,-594.999999999906));
#3138=LINE('',#3137,#3136);
#3139=CARTESIAN_POINT('',(30.500000000005,15.000000000001,-594.999999999906));
#3140=VERTEX_POINT('',#3139);
#3141=EDGE_CURVE('E1015',#3109,#3140,#3138,.F.);
#3142=ORIENTED_EDGE('',*,*,#3141,.T.);
#3143=DIRECTION('',(0.,0.,1.));
#3144=VECTOR('',#3143,1.);
#3145=CARTESIAN_POINT('',(30.500000000005,15.000000000001,-594.999999999906));
#3146=LINE('',#3145,#3144);
#3147=CARTESIAN_POINT('',(30.500000000005,15.000000000001,0.));
#3148=VERTEX_POINT('',#3147);
#3149=EDGE_CURVE('E1146',#3140,#3148,#3146,.T.);
#3150=ORIENTED_EDGE('',*,*,#3149,.T.);
#3151=DIRECTION('',(0.,1.,0.));
#3152=VECTOR('',#3151,1.);
#3153=CARTESIAN_POINT('',(30.500000000005,-35.0000000000124,0.));
#3154=LINE('',#3153,#3152);
#3155=EDGE_CURVE('E930',#3117,#3148,#3154,.F.);
#3156=ORIENTED_EDGE('',*,*,#3155,.F.);
#3157=EDGE_LOOP('',(#3134,#3142,#3150,#3156));
#3158=FACE_BOUND('',#3157,.T.);
#3159=ADVANCED_FACE('F1901',(#3158),#3133,.F.);
#3160=CARTESIAN_POINT('',(30.500000000005,15.000000000001,-594.999999999906));
#3161=DIRECTION('',(0.,1.,0.));
#3162=DIRECTION('',(0.,0.,1.));
#3163=AXIS2_PLACEMENT_3D('',#3160,#3161,#3162);
#3164=PLANE('',#3163);
#3165=ORIENTED_EDGE('',*,*,#3149,.F.);
#3166=DIRECTION('',(1.,0.,0.));
#3167=VECTOR('',#3166,1.);
#3168=CARTESIAN_POINT('',(-84.9999999999902,15.000000000001,-594.999999999906));
#3169=LINE('',#3168,#3167);
#3170=CARTESIAN_POINT('',(39.9999999999924,15.000000000001,-594.999999999906));
#3171=VERTEX_POINT('',#3170);
#3172=EDGE_CURVE('E1012',#3140,#3171,#3169,.T.);
#3173=ORIENTED_EDGE('',*,*,#3172,.T.);
#3174=DIRECTION('',(0.,0.,-1.));
#3175=VECTOR('',#3174,1.);
#3176=CARTESIAN_POINT('',(39.9999999999924,15.000000000001,-594.999999999906));
#3177=LINE('',#3176,#3175);
#3178=CARTESIAN_POINT('',(39.9999999999924,15.000000000001,0.));
#3179=VERTEX_POINT('',#3178);
#3180=EDGE_CURVE('E1143',#3171,#3179,#3177,.F.);
#3181=ORIENTED_EDGE('',*,*,#3180,.T.);
#3182=DIRECTION('',(1.,0.,0.));
#3183=VECTOR('',#3182,1.);
#3184=CARTESIAN_POINT('',(-84.9999999999902,15.000000000001,0.));
#3185=LINE('',#3184,#3183);
#3186=EDGE_CURVE('E928',#3148,#3179,#3185,.T.);
#3187=ORIENTED_EDGE('',*,*,#3186,.F.);
#3188=EDGE_LOOP('',(#3165,#3173,#3181,#3187));
#3189=FACE_BOUND('',#3188,.T.);
#3190=ADVANCED_FACE('F1897',(#3189),#3164,.F.);
#3191=CARTESIAN_POINT('',(39.9999999999924,15.000000000001,-594.999999999906));
#3192=DIRECTION('',(1.,0.,0.));
#3193=DIRECTION('',(0.,0.,-1.));
#3194=AXIS2_PLACEMENT_3D('',#3191,#3192,#3193);
#3195=PLANE('',#3194);
#3196=ORIENTED_EDGE('',*,*,#3180,.F.);
#3197=DIRECTION('',(0.,1.,0.));
#3198=VECTOR('',#3197,1.);
#3199=CARTESIAN_POINT('',(39.9999999999924,-35.0000000000124,-594.999999999906));
#3200=LINE('',#3199,#3198);
#3201=CARTESIAN_POINT('',(39.9999999999924,-3.0000000000007,-594.999999999906));
#3202=VERTEX_POINT('',#3201);
#3203=EDGE_CURVE('E1009',#3171,#3202,#3200,.F.);
#3204=ORIENTED_EDGE('',*,*,#3203,.T.);
#3205=DIRECTION('',(0.,0.,-1.));
#3206=VECTOR('',#3205,1.);
#3207=CARTESIAN_POINT('',(39.9999999999924,-3.0000000000007,-594.999999999906));
#3208=LINE('',#3207,#3206);
#3209=CARTESIAN_POINT('',(39.9999999999924,-3.0000000000007,0.));
#3210=VERTEX_POINT('',#3209);
#3211=EDGE_CURVE('E1140',#3202,#3210,#3208,.F.);
#3212=ORIENTED_EDGE('',*,*,#3211,.T.);
#3213=DIRECTION('',(0.,1.,0.));
#3214=VECTOR('',#3213,1.);
#3215=CARTESIAN_POINT('',(39.9999999999924,-35.0000000000124,0.));
#3216=LINE('',#3215,#3214);
#3217=EDGE_CURVE('E926',#3179,#3210,#3216,.F.);
#3218=ORIENTED_EDGE('',*,*,#3217,.F.);
#3219=EDGE_LOOP('',(#3196,#3204,#3212,#3218));
#3220=FACE_BOUND('',#3219,.T.);
#3221=ADVANCED_FACE('F1892',(#3220),#3195,.F.);
#3222=CARTESIAN_POINT('',(39.9999999999924,-3.0000000000007,-594.999999999906));
#3223=DIRECTION('',(0.,-1.,0.));
#3224=DIRECTION('',(0.,0.,-1.));
#3225=AXIS2_PLACEMENT_3D('',#3222,#3223,#3224);
#3226=PLANE('',#3225);
#3227=ORIENTED_EDGE('',*,*,#3211,.F.);
#3228=DIRECTION('',(1.,0.,0.));
#3229=VECTOR('',#3228,1.);
#3230=CARTESIAN_POINT('',(-84.9999999999902,-3.0000000000007,-594.999999999906));
#3231=LINE('',#3230,#3229);
#3232=CARTESIAN_POINT('',(30.8000000000041,-3.00000000000104,-594.999999999906));
#3233=VERTEX_POINT('',#3232);
#3234=EDGE_CURVE('E1007',#3202,#3233,#3231,.F.);
#3235=ORIENTED_EDGE('',*,*,#3234,.T.);
#3236=DIRECTION('',(0.,0.,1.));
#3237=VECTOR('',#3236,1.);
#3238=CARTESIAN_POINT('',(30.8000000000051,-3.00000000000203,-594.999999999906));
#3239=LINE('',#3238,#3237);
#3240=CARTESIAN_POINT('',(30.8000000000041,-3.00000000000104,0.));
#3241=VERTEX_POINT('',#3240);
#3242=EDGE_CURVE('E951',#3233,#3241,#3239,.T.);
#3243=ORIENTED_EDGE('',*,*,#3242,.T.);
#3244=DIRECTION('',(1.,0.,0.));
#3245=VECTOR('',#3244,1.);
#3246=CARTESIAN_POINT('',(-84.9999999999902,-3.0000000000007,0.));
#3247=LINE('',#3246,#3245);
#3248=EDGE_CURVE('E924',#3210,#3241,#3247,.F.);
#3249=ORIENTED_EDGE('',*,*,#3248,.F.);
#3250=EDGE_LOOP('',(#3227,#3235,#3243,#3249));
#3251=FACE_BOUND('',#3250,.T.);
#3252=ADVANCED_FACE('F2054',(#3251),#3226,.F.);
#3253=CARTESIAN_POINT('',(-39.9999999999924,-3.0000000000007,-594.999999999906));
#3254=DIRECTION('',(0.,-1.,0.));
#3255=DIRECTION('',(0.,0.,-1.));
#3256=AXIS2_PLACEMENT_3D('',#3253,#3254,#3255);
#3257=PLANE('',#3256);
#3258=DIRECTION('',(0.,0.,1.));
#3259=VECTOR('',#3258,1.);
#3260=CARTESIAN_POINT('',(-30.8000000000051,-3.00000000000203,-594.999999999906));
#3261=LINE('',#3260,#3259);
#3262=CARTESIAN_POINT('',(-30.8000000000045,-3.00000000000136,0.));
#3263=VERTEX_POINT('',#3262);
#3264=CARTESIAN_POINT('',(-30.8000000000045,-3.00000000000136,-594.999999999906));
#3265=VERTEX_POINT('',#3264);
#3266=EDGE_CURVE('E1049',#3263,#3265,#3261,.F.);
#3267=ORIENTED_EDGE('',*,*,#3266,.T.);
#3268=DIRECTION('',(1.,0.,0.));
#3269=VECTOR('',#3268,1.);
#3270=CARTESIAN_POINT('',(-84.9999999999902,-3.0000000000007,-594.999999999906));
#3271=LINE('',#3270,#3269);
#3272=CARTESIAN_POINT('',(-39.9999999999924,-3.0000000000007,-594.999999999906));
#3273=VERTEX_POINT('',#3272);
#3274=EDGE_CURVE('E1001',#3265,#3273,#3271,.F.);
#3275=ORIENTED_EDGE('',*,*,#3274,.T.);
#3276=DIRECTION('',(0.,0.,1.));
#3277=VECTOR('',#3276,1.);
#3278=CARTESIAN_POINT('',(-39.9999999999924,-3.0000000000007,-594.999999999906));
#3279=LINE('',#3278,#3277);
#3280=CARTESIAN_POINT('',(-39.9999999999924,-3.0000000000007,0.));
#3281=VERTEX_POINT('',#3280);
#3282=EDGE_CURVE('E1137',#3273,#3281,#3279,.T.);
#3283=ORIENTED_EDGE('',*,*,#3282,.T.);
#3284=DIRECTION('',(1.,0.,0.));
#3285=VECTOR('',#3284,1.);
#3286=CARTESIAN_POINT('',(-84.9999999999902,-3.0000000000007,0.));
#3287=LINE('',#3286,#3285);
#3288=EDGE_CURVE('E918',#3263,#3281,#3287,.F.);
#3289=ORIENTED_EDGE('',*,*,#3288,.F.);
#3290=EDGE_LOOP('',(#3267,#3275,#3283,#3289));
#3291=FACE_BOUND('',#3290,.T.);
#3292=ADVANCED_FACE('F1875',(#3291),#3257,.F.);
#3293=CARTESIAN_POINT('',(-39.9999999999924,15.000000000001,-594.999999999906));
#3294=DIRECTION('',(-1.,0.,0.));
#3295=DIRECTION('',(0.,0.,1.));
#3296=AXIS2_PLACEMENT_3D('',#3293,#3294,#3295);
#3297=PLANE('',#3296);
#3298=ORIENTED_EDGE('',*,*,#3282,.F.);
#3299=DIRECTION('',(0.,1.,0.));
#3300=VECTOR('',#3299,1.);
#3301=CARTESIAN_POINT('',(-39.9999999999924,-35.0000000000124,-594.999999999906));
#3302=LINE('',#3301,#3300);
#3303=CARTESIAN_POINT('',(-39.9999999999924,15.000000000001,-594.999999999906));
#3304=VERTEX_POINT('',#3303);
#3305=EDGE_CURVE('E998',#3273,#3304,#3302,.T.);
#3306=ORIENTED_EDGE('',*,*,#3305,.T.);
#3307=DIRECTION('',(0.,0.,1.));
#3308=VECTOR('',#3307,1.);
#3309=CARTESIAN_POINT('',(-39.9999999999924,15.000000000001,-594.999999999906));
#3310=LINE('',#3309,#3308);
#3311=CARTESIAN_POINT('',(-39.9999999999924,15.000000000001,0.));
#3312=VERTEX_POINT('',#3311);
#3313=EDGE_CURVE('E1134',#3304,#3312,#3310,.T.);
#3314=ORIENTED_EDGE('',*,*,#3313,.T.);
#3315=DIRECTION('',(0.,1.,0.));
#3316=VECTOR('',#3315,1.);
#3317=CARTESIAN_POINT('',(-39.9999999999924,-35.0000000000124,0.));
#3318=LINE('',#3317,#3316);
#3319=EDGE_CURVE('E916',#3281,#3312,#3318,.T.);
#3320=ORIENTED_EDGE('',*,*,#3319,.F.);
#3321=EDGE_LOOP('',(#3298,#3306,#3314,#3320));
#3322=FACE_BOUND('',#3321,.T.);
#3323=ADVANCED_FACE('F1872',(#3322),#3297,.F.);
#3324=CARTESIAN_POINT('',(-30.500000000005,15.000000000001,-594.999999999906));
#3325=DIRECTION('',(0.,1.,0.));
#3326=DIRECTION('',(0.,0.,1.));
#3327=AXIS2_PLACEMENT_3D('',#3324,#3325,#3326);
#3328=PLANE('',#3327);
#3329=ORIENTED_EDGE('',*,*,#3313,.F.);
#3330=DIRECTION('',(1.,0.,0.));
#3331=VECTOR('',#3330,1.);
#3332=CARTESIAN_POINT('',(-84.9999999999902,15.000000000001,-594.999999999906));
#3333=LINE('',#3332,#3331);
#3334=CARTESIAN_POINT('',(-30.500000000005,15.000000000001,-594.999999999906));
#3335=VERTEX_POINT('',#3334);
#3336=EDGE_CURVE('E995',#3304,#3335,#3333,.T.);
#3337=ORIENTED_EDGE('',*,*,#3336,.T.);
#3338=DIRECTION('',(0.,0.,1.));
#3339=VECTOR('',#3338,1.);
#3340=CARTESIAN_POINT('',(-30.500000000005,15.000000000001,-594.999999999906));
#3341=LINE('',#3340,#3339);
#3342=CARTESIAN_POINT('',(-30.500000000005,15.000000000001,0.));
#3343=VERTEX_POINT('',#3342);
#3344=EDGE_CURVE('E1131',#3335,#3343,#3341,.T.);
#3345=ORIENTED_EDGE('',*,*,#3344,.T.);
#3346=DIRECTION('',(1.,0.,0.));
#3347=VECTOR('',#3346,1.);
#3348=CARTESIAN_POINT('',(-84.9999999999902,15.000000000001,0.));
#3349=LINE('',#3348,#3347);
#3350=EDGE_CURVE('E914',#3312,#3343,#3349,.T.);
#3351=ORIENTED_EDGE('',*,*,#3350,.F.);
#3352=EDGE_LOOP('',(#3329,#3337,#3345,#3351));
#3353=FACE_BOUND('',#3352,.T.);
#3354=ADVANCED_FACE('F1868',(#3353),#3328,.F.);
#3355=CARTESIAN_POINT('',(-30.500000000005,15.000000000001,-594.999999999906));
#3356=DIRECTION('',(-1.,0.,0.));
#3357=DIRECTION('',(0.,0.,1.));
#3358=AXIS2_PLACEMENT_3D('',#3355,#3356,#3357);
#3359=PLANE('',#3358);
#3360=ORIENTED_EDGE('',*,*,#3344,.F.);
#3361=DIRECTION('',(0.,1.,0.));
#3362=VECTOR('',#3361,1.);
#3363=CARTESIAN_POINT('',(-30.500000000005,-35.0000000000124,-594.999999999906));
#3364=LINE('',#3363,#3362);
#3365=CARTESIAN_POINT('',(-30.5000000000034,21.5358983848617,-594.999999999906));
#3366=VERTEX_POINT('',#3365);
#3367=EDGE_CURVE('E992',#3335,#3366,#3364,.T.);
#3368=ORIENTED_EDGE('',*,*,#3367,.T.);
#3369=DIRECTION('',(0.,0.,1.));
#3370=VECTOR('',#3369,1.);
#3371=CARTESIAN_POINT('',(-30.4999999999987,21.5358983848644,-594.999999999906));
#3372=LINE('',#3371,#3370);
#3373=CARTESIAN_POINT('',(-30.5000000000034,21.5358983848617,0.));
#3374=VERTEX_POINT('',#3373);
#3375=EDGE_CURVE('E1128',#3366,#3374,#3372,.T.);
#3376=ORIENTED_EDGE('',*,*,#3375,.T.);
#3377=DIRECTION('',(0.,1.,0.));
#3378=VECTOR('',#3377,1.);
#3379=CARTESIAN_POINT('',(-30.500000000005,-35.0000000000124,0.));
#3380=LINE('',#3379,#3378);
#3381=EDGE_CURVE('E912',#3343,#3374,#3380,.T.);
#3382=ORIENTED_EDGE('',*,*,#3381,.F.);
#3383=EDGE_LOOP('',(#3360,#3368,#3376,#3382));
#3384=FACE_BOUND('',#3383,.T.);
#3385=ADVANCED_FACE('F1864',(#3384),#3359,.F.);
#3386=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,-594.999999999906));
#3387=DIRECTION('',(-0.866025403784429,-0.500000000000017,0.));
#3388=DIRECTION('',(0.500000000000017,-0.866025403784429,0.));
#3389=AXIS2_PLACEMENT_3D('',#3386,#3387,#3388);
#3390=PLANE('',#3389);
#3391=ORIENTED_EDGE('',*,*,#3375,.F.);
#3392=DIRECTION('',(-0.499999999998446,0.866025403785336,0.));
#3393=VECTOR('',#3392,1.);
#3394=CARTESIAN_POINT('',(-30.500000000005,21.5358983848608,-594.999999999906));
#3395=LINE('',#3394,#3393);
#3396=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,-594.999999999906));
#3397=VERTEX_POINT('',#3396);
#3398=EDGE_CURVE('E989',#3366,#3397,#3395,.T.);
#3399=ORIENTED_EDGE('',*,*,#3398,.T.);
#3400=DIRECTION('',(0.,0.,1.));
#3401=VECTOR('',#3400,1.);
#3402=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,-594.999999999906));
#3403=LINE('',#3402,#3401);
#3404=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,0.));
#3405=VERTEX_POINT('',#3404);
#3406=EDGE_CURVE('E1125',#3397,#3405,#3403,.T.);
#3407=ORIENTED_EDGE('',*,*,#3406,.T.);
#3408=DIRECTION('',(-0.499999999998446,0.866025403785336,0.));
#3409=VECTOR('',#3408,1.);
#3410=CARTESIAN_POINT('',(-30.500000000005,21.5358983848608,0.));
#3411=LINE('',#3410,#3409);
#3412=EDGE_CURVE('E910',#3374,#3405,#3411,.T.);
#3413=ORIENTED_EDGE('',*,*,#3412,.F.);
#3414=EDGE_LOOP('',(#3391,#3399,#3407,#3413));
#3415=FACE_BOUND('',#3414,.T.);
#3416=ADVANCED_FACE('F1861',(#3415),#3390,.F.);
#3417=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,-594.999999999906));
#3418=DIRECTION('',(-0.866025403784429,0.500000000000017,0.));
#3419=DIRECTION('',(-0.500000000000017,-0.866025403784429,0.));
#3420=AXIS2_PLACEMENT_3D('',#3417,#3418,#3419);
#3421=PLANE('',#3420);
#3422=ORIENTED_EDGE('',*,*,#3406,.F.);
#3423=DIRECTION('',(0.499999999997896,0.866025403785653,0.));
#3424=VECTOR('',#3423,1.);
#3425=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,-594.999999999906));
#3426=LINE('',#3425,#3424);
#3427=CARTESIAN_POINT('',(-30.5000000000008,28.4641016151399,-594.999999999906));
#3428=VERTEX_POINT('',#3427);
#3429=EDGE_CURVE('E986',#3397,#3428,#3426,.T.);
#3430=ORIENTED_EDGE('',*,*,#3429,.T.);
#3431=DIRECTION('',(0.,0.,1.));
#3432=VECTOR('',#3431,1.);
#3433=CARTESIAN_POINT('',(-30.500000000005,28.4641016151424,-594.999999999906));
#3434=LINE('',#3433,#3432);
#3435=CARTESIAN_POINT('',(-30.5000000000008,28.4641016151399,0.));
#3436=VERTEX_POINT('',#3435);
#3437=EDGE_CURVE('E1111',#3428,#3436,#3434,.T.);
#3438=ORIENTED_EDGE('',*,*,#3437,.T.);
#3439=DIRECTION('',(0.499999999997896,0.866025403785653,0.));
#3440=VECTOR('',#3439,1.);
#3441=CARTESIAN_POINT('',(-32.499999999997,24.9999999999991,0.));
#3442=LINE('',#3441,#3440);
#3443=EDGE_CURVE('E908',#3405,#3436,#3442,.T.);
#3444=ORIENTED_EDGE('',*,*,#3443,.F.);
#3445=EDGE_LOOP('',(#3422,#3430,#3438,#3444));
#3446=FACE_BOUND('',#3445,.T.);
#3447=ADVANCED_FACE('F1856',(#3446),#3421,.F.);
#3448=CARTESIAN_POINT('',(-30.500000000005,28.4641016151424,-594.999999999906));
#3449=DIRECTION('',(-1.,0.,0.));
#3450=DIRECTION('',(0.,0.,1.));
#3451=AXIS2_PLACEMENT_3D('',#3448,#3449,#3450);
#3452=PLANE('',#3451);
#3453=ORIENTED_EDGE('',*,*,#3437,.F.);
#3454=DIRECTION('',(0.,1.,0.));
#3455=VECTOR('',#3454,1.);
#3456=CARTESIAN_POINT('',(-30.500000000005,-35.0000000000124,-594.999999999906));
#3457=LINE('',#3456,#3455);
#3458=EDGE_CURVE('E983',#3428,#2584,#3457,.T.);
#3459=ORIENTED_EDGE('',*,*,#3458,.T.);
#3460=ORIENTED_EDGE('',*,*,#2585,.F.);
#3461=ORIENTED_EDGE('',*,*,#1985,.F.);
#3462=ORIENTED_EDGE('',*,*,#1954,.F.);
#3463=ORIENTED_EDGE('',*,*,#1916,.F.);
#3464=DIRECTION('',(0.,0.,1.));
#3465=VECTOR('',#3464,1.);
#3466=CARTESIAN_POINT('',(-30.500000000005,35.0000000000124,-594.999999999906));
#3467=LINE('',#3466,#3465);
#3468=CARTESIAN_POINT('',(-30.500000000005,35.0000000000124,0.));
#3469=VERTEX_POINT('',#3468);
#3470=EDGE_CURVE('E1108',#3469,#1913,#3467,.F.);
#3471=ORIENTED_EDGE('',*,*,#3470,.F.);
#3472=DIRECTION('',(0.,1.,0.));
#3473=VECTOR('',#3472,1.);
#3474=CARTESIAN_POINT('',(-30.500000000005,-35.0000000000124,0.));
#3475=LINE('',#3474,#3473);
#3476=EDGE_CURVE('E906',#3436,#3469,#3475,.T.);
#3477=ORIENTED_EDGE('',*,*,#3476,.F.);
#3478=EDGE_LOOP('',(#3453,#3459,#3460,#3461,#3462,#3463,#3471,#3477));
#3479=FACE_BOUND('',#3478,.T.);
#3480=ADVANCED_FACE('F1833',(#3479),#3452,.F.);
#3481=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#3482=DIRECTION('',(0.,1.,0.));
#3483=DIRECTION('',(0.,0.,1.));
#3484=AXIS2_PLACEMENT_3D('',#3481,#3482,#3483);
#3485=PLANE('',#3484);
#3486=ORIENTED_EDGE('',*,*,#1895,.T.);
#3487=EDGE_LOOP('',(#3486));
#3488=FACE_BOUND('',#3487,.T.);
#3489=ORIENTED_EDGE('',*,*,#3470,.T.);
#3490=ORIENTED_EDGE('',*,*,#1938,.T.);
#3491=DIRECTION('',(0.,0.,1.));
#3492=VECTOR('',#3491,1.);
#3493=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#3494=LINE('',#3493,#3492);
#3495=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,0.));
#3496=VERTEX_POINT('',#3495);
#3497=EDGE_CURVE('E696',#3496,#1931,#3494,.F.);
#3498=ORIENTED_EDGE('',*,*,#3497,.F.);
#3499=DIRECTION('',(1.,0.,0.));
#3500=VECTOR('',#3499,1.);
#3501=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,0.));
#3502=LINE('',#3501,#3500);
#3503=EDGE_CURVE('E904',#3469,#3496,#3502,.F.);
#3504=ORIENTED_EDGE('',*,*,#3503,.F.);
#3505=EDGE_LOOP('',(#3489,#3490,#3498,#3504));
#3506=FACE_BOUND('',#3505,.T.);
#3507=ADVANCED_FACE('F1850',(#3488,#3506),#3485,.T.);
#3508=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#3509=DIRECTION('',(-1.,0.,0.));
#3510=DIRECTION('',(0.,0.,1.));
#3511=AXIS2_PLACEMENT_3D('',#3508,#3509,#3510);
#3512=PLANE('',#3511);
#3513=DIRECTION('',(0.,0.,-1.));
#3514=VECTOR('',#3513,1.);
#3515=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,-594.999999999906));
#3516=LINE('',#3515,#3514);
#3517=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,0.));
#3518=VERTEX_POINT('',#3517);
#3519=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,-594.999999999906));
#3520=VERTEX_POINT('',#3519);
#3521=EDGE_CURVE('E1095',#3518,#3520,#3516,.T.);
#3522=ORIENTED_EDGE('',*,*,#3521,.F.);
#3523=DIRECTION('',(0.,1.,0.));
#3524=VECTOR('',#3523,1.);
#3525=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#3526=LINE('',#3525,#3524);
#3527=EDGE_CURVE('E902',#3496,#3518,#3526,.F.);
#3528=ORIENTED_EDGE('',*,*,#3527,.F.);
#3529=ORIENTED_EDGE('',*,*,#3497,.T.);
#3530=ORIENTED_EDGE('',*,*,#1932,.T.);
#3531=ORIENTED_EDGE('',*,*,#1968,.T.);
#3532=ORIENTED_EDGE('',*,*,#1999,.T.);
#3533=ORIENTED_EDGE('',*,*,#2576,.T.);
#3534=DIRECTION('',(0.,1.,0.));
#3535=VECTOR('',#3534,1.);
#3536=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#3537=LINE('',#3536,#3535);
#3538=EDGE_CURVE('E977',#2575,#3520,#3537,.F.);
#3539=ORIENTED_EDGE('',*,*,#3538,.T.);
#3540=EDGE_LOOP('',(#3522,#3528,#3529,#3530,#3531,#3532,#3533,#3539));
#3541=FACE_BOUND('',#3540,.T.);
#3542=ADVANCED_FACE('F1823',(#3541),#3512,.T.);
#3543=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,-594.999999999906));
#3544=DIRECTION('',(0.,-1.,0.));
#3545=DIRECTION('',(0.,0.,-1.));
#3546=AXIS2_PLACEMENT_3D('',#3543,#3544,#3545);
#3547=PLANE('',#3546);
#3548=DIRECTION('',(1.,0.,0.));
#3549=VECTOR('',#3548,1.);
#3550=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,0.));
#3551=LINE('',#3550,#3549);
#3552=CARTESIAN_POINT('',(-75.0000000000048,8.49999999999902,0.));
#3553=VERTEX_POINT('',#3552);
#3554=EDGE_CURVE('E900',#3518,#3553,#3551,.T.);
#3555=ORIENTED_EDGE('',*,*,#3554,.F.);
#3556=ORIENTED_EDGE('',*,*,#3521,.T.);
#3557=DIRECTION('',(1.,0.,0.));
#3558=VECTOR('',#3557,1.);
#3559=CARTESIAN_POINT('',(-84.9999999999902,8.49999999999902,-594.999999999906));
#3560=LINE('',#3559,#3558);
#3561=CARTESIAN_POINT('',(-75.0000000000048,8.49999999999902,-594.999999999906));
#3562=VERTEX_POINT('',#3561);
#3563=EDGE_CURVE('E974',#3520,#3562,#3560,.T.);
#3564=ORIENTED_EDGE('',*,*,#3563,.T.);
#3565=DIRECTION('',(0.,0.,1.));
#3566=VECTOR('',#3565,1.);
#3567=CARTESIAN_POINT('',(-75.0000000000048,8.49999999999902,-594.999999999906));
#3568=LINE('',#3567,#3566);
#3569=EDGE_CURVE('E1093',#3553,#3562,#3568,.F.);
#3570=ORIENTED_EDGE('',*,*,#3569,.F.);
#3571=EDGE_LOOP('',(#3555,#3556,#3564,#3570));
#3572=FACE_BOUND('',#3571,.T.);
#3573=ADVANCED_FACE('F1819',(#3572),#3547,.T.);
#3574=CARTESIAN_POINT('',(-75.0000000000048,8.49999999999902,-594.999999999906));
#3575=DIRECTION('',(-1.,0.,0.));
#3576=DIRECTION('',(0.,0.,1.));
#3577=AXIS2_PLACEMENT_3D('',#3574,#3575,#3576);
#3578=PLANE('',#3577);
#3579=DIRECTION('',(0.,1.,0.));
#3580=VECTOR('',#3579,1.);
#3581=CARTESIAN_POINT('',(-75.0000000000048,-35.0000000000124,0.));
#3582=LINE('',#3581,#3580);
#3583=CARTESIAN_POINT('',(-75.0000000000048,-8.99999999999956,0.));
#3584=VERTEX_POINT('',#3583);
#3585=EDGE_CURVE('E898',#3553,#3584,#3582,.F.);
#3586=ORIENTED_EDGE('',*,*,#3585,.F.);
#3587=ORIENTED_EDGE('',*,*,#3569,.T.);
#3588=DIRECTION('',(0.,1.,0.));
#3589=VECTOR('',#3588,1.);
#3590=CARTESIAN_POINT('',(-75.0000000000048,-35.0000000000124,-594.999999999906));
#3591=LINE('',#3590,#3589);
#3592=CARTESIAN_POINT('',(-75.0000000000048,-8.99999999999956,-594.999999999906));
#3593=VERTEX_POINT('',#3592);
#3594=EDGE_CURVE('E971',#3562,#3593,#3591,.F.);
#3595=ORIENTED_EDGE('',*,*,#3594,.T.);
#3596=DIRECTION('',(0.,0.,1.));
#3597=VECTOR('',#3596,1.);
#3598=CARTESIAN_POINT('',(-75.0000000000048,-8.99999999999956,-594.999999999906));
#3599=LINE('',#3598,#3597);
#3600=EDGE_CURVE('E1091',#3584,#3593,#3599,.F.);
#3601=ORIENTED_EDGE('',*,*,#3600,.F.);
#3602=EDGE_LOOP('',(#3586,#3587,#3595,#3601));
#3603=FACE_BOUND('',#3602,.T.);
#3604=ADVANCED_FACE('F1813',(#3603),#3578,.T.);
#3605=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,-594.999999999906));
#3606=DIRECTION('',(0.,1.,0.));
#3607=DIRECTION('',(0.,0.,1.));
#3608=AXIS2_PLACEMENT_3D('',#3605,#3606,#3607);
#3609=PLANE('',#3608);
#3610=DIRECTION('',(1.,0.,0.));
#3611=VECTOR('',#3610,1.);
#3612=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,0.));
#3613=LINE('',#3612,#3611);
#3614=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,0.));
#3615=VERTEX_POINT('',#3614);
#3616=EDGE_CURVE('E896',#3584,#3615,#3613,.F.);
#3617=ORIENTED_EDGE('',*,*,#3616,.F.);
#3618=ORIENTED_EDGE('',*,*,#3600,.T.);
#3619=DIRECTION('',(1.,0.,0.));
#3620=VECTOR('',#3619,1.);
#3621=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,-594.999999999906));
#3622=LINE('',#3621,#3620);
#3623=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,-594.999999999906));
#3624=VERTEX_POINT('',#3623);
#3625=EDGE_CURVE('E968',#3593,#3624,#3622,.F.);
#3626=ORIENTED_EDGE('',*,*,#3625,.T.);
#3627=DIRECTION('',(0.,0.,1.));
#3628=VECTOR('',#3627,1.);
#3629=CARTESIAN_POINT('',(-84.9999999999902,-8.99999999999956,-594.999999999906));
#3630=LINE('',#3629,#3628);
#3631=EDGE_CURVE('E1089',#3615,#3624,#3630,.F.);
#3632=ORIENTED_EDGE('',*,*,#3631,.F.);
#3633=EDGE_LOOP('',(#3617,#3618,#3626,#3632));
#3634=FACE_BOUND('',#3633,.T.);
#3635=ADVANCED_FACE('F1809',(#3634),#3609,.T.);
#3636=CARTESIAN_POINT('',(-84.9999999999902,35.0000000000124,-594.999999999906));
#3637=DIRECTION('',(-1.,0.,0.));
#3638=DIRECTION('',(0.,0.,1.));
#3639=AXIS2_PLACEMENT_3D('',#3636,#3637,#3638);
#3640=PLANE('',#3639);
#3641=DIRECTION('',(0.,0.,-1.));
#3642=VECTOR('',#3641,1.);
#3643=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#3644=LINE('',#3643,#3642);
#3645=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#3646=VERTEX_POINT('',#3645);
#3647=EDGE_CURVE('E1078',#3646,#2107,#3644,.T.);
#3648=ORIENTED_EDGE('',*,*,#3647,.F.);
#3649=DIRECTION('',(0.,1.,0.));
#3650=VECTOR('',#3649,1.);
#3651=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#3652=LINE('',#3651,#3650);
#3653=EDGE_CURVE('E894',#3615,#3646,#3652,.F.);
#3654=ORIENTED_EDGE('',*,*,#3653,.F.);
#3655=ORIENTED_EDGE('',*,*,#3631,.T.);
#3656=DIRECTION('',(0.,1.,0.));
#3657=VECTOR('',#3656,1.);
#3658=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#3659=LINE('',#3658,#3657);
#3660=EDGE_CURVE('E965',#3624,#2608,#3659,.F.);
#3661=ORIENTED_EDGE('',*,*,#3660,.T.);
#3662=ORIENTED_EDGE('',*,*,#2609,.T.);
#3663=ORIENTED_EDGE('',*,*,#2018,.T.);
#3664=ORIENTED_EDGE('',*,*,#2081,.T.);
#3665=ORIENTED_EDGE('',*,*,#2114,.T.);
#3666=EDGE_LOOP('',(#3648,#3654,#3655,#3661,#3662,#3663,#3664,#3665));
#3667=FACE_BOUND('',#3666,.T.);
#3668=ADVANCED_FACE('F1802',(#3667),#3640,.T.);
#3669=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#3670=DIRECTION('',(0.,-1.,0.));
#3671=DIRECTION('',(0.,0.,-1.));
#3672=AXIS2_PLACEMENT_3D('',#3669,#3670,#3671);
#3673=PLANE('',#3672);
#3674=ORIENTED_EDGE('',*,*,#3647,.T.);
#3675=ORIENTED_EDGE('',*,*,#2108,.T.);
#3676=ORIENTED_EDGE('',*,*,#2258,.T.);
#3677=DIRECTION('',(1.,0.,0.));
#3678=VECTOR('',#3677,1.);
#3679=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#3680=LINE('',#3679,#3678);
#3681=EDGE_CURVE('E890',#3646,#2251,#3680,.T.);
#3682=ORIENTED_EDGE('',*,*,#3681,.F.);
#3683=EDGE_LOOP('',(#3674,#3675,#3676,#3682));
#3684=FACE_BOUND('',#3683,.T.);
#3685=ADVANCED_FACE('F2023',(#3684),#3673,.T.);
#3686=CARTESIAN_POINT('',(-41.5000000000118,-33.999999999991,-594.999999999906));
#3687=DIRECTION('',(0.,1.,0.));
#3688=DIRECTION('',(0.,0.,1.));
#3689=AXIS2_PLACEMENT_3D('',#3686,#3687,#3688);
#3690=PLANE('',#3689);
#3691=ORIENTED_EDGE('',*,*,#2244,.F.);
#3692=ORIENTED_EDGE('',*,*,#2129,.F.);
#3693=ORIENTED_EDGE('',*,*,#2217,.F.);
#3694=ORIENTED_EDGE('',*,*,#2186,.F.);
#3695=ORIENTED_EDGE('',*,*,#2169,.F.);
#3696=DIRECTION('',(1.,0.,0.));
#3697=VECTOR('',#3696,1.);
#3698=CARTESIAN_POINT('',(-84.9999999999902,-33.999999999991,0.));
#3699=LINE('',#3698,#3697);
#3700=EDGE_CURVE('E893',#2243,#2162,#3699,.T.);
#3701=ORIENTED_EDGE('',*,*,#3700,.F.);
#3702=EDGE_LOOP('',(#3691,#3692,#3693,#3694,#3695,#3701));
#3703=FACE_BOUND('',#3702,.T.);
#3704=ADVANCED_FACE('F1765',(#3703),#3690,.F.);
#3705=CARTESIAN_POINT('',(0.,-4.38000000001167,-69.0000000000034));
#3706=DIRECTION('',(0.,1.,0.));
#3707=DIRECTION('',(0.,0.,1.));
#3708=AXIS2_PLACEMENT_3D('',#3705,#3706,#3707);
#3709=CONICAL_SURFACE('',#3708,12.9999999999975,0.785398163397125);
#3710=CARTESIAN_POINT('',(0.,-4.38000000001232,-69.0000000000034));
#3711=DIRECTION('',(0.,1.,0.));
#3712=DIRECTION('',(0.,0.,1.));
#3713=AXIS2_PLACEMENT_3D('',#3710,#3711,#3712);
#3714=CIRCLE('',#3713,12.9999999999984);
#3715=CARTESIAN_POINT('',(0.,-4.38000000001232,-56.000000000005));
#3716=VERTEX_POINT('',#3715);
#3717=EDGE_CURVE('E1067',#3716,#3716,#3714,.T.);
#3718=ORIENTED_EDGE('',*,*,#3717,.T.);
#3719=EDGE_LOOP('',(#3718));
#3720=FACE_BOUND('',#3719,.T.);
#3721=ORIENTED_EDGE('',*,*,#2276,.F.);
#3722=EDGE_LOOP('',(#3721));
#3723=FACE_BOUND('',#3722,.T.);
#3724=ADVANCED_FACE('F2016',(#3720,#3723),#3709,.F.);
#3725=CARTESIAN_POINT('',(0.,-4.38000000001167,-109.499999999994));
#3726=DIRECTION('',(0.,1.,0.));
#3727=DIRECTION('',(-1.,0.,0.));
#3728=AXIS2_PLACEMENT_3D('',#3725,#3726,#3727);
#3729=CONICAL_SURFACE('',#3728,12.9999999999975,0.785398163397126);
#3730=CARTESIAN_POINT('',(0.,-4.38000000001232,-109.499999999994));
#3731=DIRECTION('',(0.,1.,0.));
#3732=DIRECTION('',(0.,0.,1.));
#3733=AXIS2_PLACEMENT_3D('',#3730,#3731,#3732);
#3734=CIRCLE('',#3733,12.9999999999984);
#3735=CARTESIAN_POINT('',(0.,-4.38000000001232,-96.4999999999954));
#3736=VERTEX_POINT('',#3735);
#3737=EDGE_CURVE('E1064',#3736,#3736,#3734,.T.);
#3738=ORIENTED_EDGE('',*,*,#3737,.T.);
#3739=EDGE_LOOP('',(#3738));
#3740=FACE_BOUND('',#3739,.T.);
#3741=ORIENTED_EDGE('',*,*,#2296,.F.);
#3742=EDGE_LOOP('',(#3741));
#3743=FACE_BOUND('',#3742,.T.);
#3744=ADVANCED_FACE('F2012',(#3740,#3743),#3729,.F.);
#3745=CARTESIAN_POINT('',(0.,-4.38000000001167,-183.333333333311));
#3746=DIRECTION('',(0.,1.,0.));
#3747=DIRECTION('',(0.,0.,1.));
#3748=AXIS2_PLACEMENT_3D('',#3745,#3746,#3747);
#3749=CONICAL_SURFACE('',#3748,12.9999999999975,0.785398163397126);
#3750=CARTESIAN_POINT('',(0.,-4.38000000001233,-183.333333333311));
#3751=DIRECTION('',(0.,1.,0.));
#3752=DIRECTION('',(0.,0.,1.));
#3753=AXIS2_PLACEMENT_3D('',#3750,#3751,#3752);
#3754=CIRCLE('',#3753,12.9999999999984);
#3755=CARTESIAN_POINT('',(0.,-4.38000000001233,-170.333333333313));
#3756=VERTEX_POINT('',#3755);
#3757=EDGE_CURVE('E1061',#3756,#3756,#3754,.T.);
#3758=ORIENTED_EDGE('',*,*,#3757,.T.);
#3759=EDGE_LOOP('',(#3758));
#3760=FACE_BOUND('',#3759,.T.);
#3761=ORIENTED_EDGE('',*,*,#2316,.F.);
#3762=EDGE_LOOP('',(#3761));
#3763=FACE_BOUND('',#3762,.T.);
#3764=ADVANCED_FACE('F2008',(#3760,#3763),#3749,.F.);
#3765=CARTESIAN_POINT('',(0.,-4.38000000001167,-216.666666666689));
#3766=DIRECTION('',(0.,1.,0.));
#3767=DIRECTION('',(0.,0.,1.));
#3768=AXIS2_PLACEMENT_3D('',#3765,#3766,#3767);
#3769=CONICAL_SURFACE('',#3768,12.9999999999975,0.785398163397125);
#3770=CARTESIAN_POINT('',(0.,-4.38000000001169,-216.666666666689));
#3771=DIRECTION('',(0.,1.,0.));
#3772=DIRECTION('',(0.,0.,1.));
#3773=AXIS2_PLACEMENT_3D('',#3770,#3771,#3772);
#3774=CIRCLE('',#3773,12.9999999999995);
#3775=CARTESIAN_POINT('',(0.,-4.38000000001169,-203.666666666689));
#3776=VERTEX_POINT('',#3775);
#3777=EDGE_CURVE('E1058',#3776,#3776,#3774,.T.);
#3778=ORIENTED_EDGE('',*,*,#3777,.T.);
#3779=EDGE_LOOP('',(#3778));
#3780=FACE_BOUND('',#3779,.T.);
#3781=ORIENTED_EDGE('',*,*,#2336,.F.);
#3782=EDGE_LOOP('',(#3781));
#3783=FACE_BOUND('',#3782,.T.);
#3784=ADVANCED_FACE('F2004',(#3780,#3783),#3769,.F.);
#3785=CARTESIAN_POINT('',(0.,-4.38000000003709,-283.333333333216));
#3786=DIRECTION('',(0.,1.,0.));
#3787=DIRECTION('',(0.,0.,1.));
#3788=AXIS2_PLACEMENT_3D('',#3785,#3786,#3787);
#3789=CONICAL_SURFACE('',#3788,12.9999999999721,0.785398163397125);
#3790=CARTESIAN_POINT('',(0.,-4.37999999992413,-283.333333333216));
#3791=DIRECTION('',(0.,1.,0.));
#3792=DIRECTION('',(0.,0.,1.));
#3793=AXIS2_PLACEMENT_3D('',#3790,#3791,#3792);
#3794=CIRCLE('',#3793,13.0000000001505);
#3795=CARTESIAN_POINT('',(0.,-4.37999999992413,-270.333333333065));
#3796=VERTEX_POINT('',#3795);
#3797=EDGE_CURVE('E1055',#3796,#3796,#3794,.T.);
#3798=ORIENTED_EDGE('',*,*,#3797,.T.);
#3799=EDGE_LOOP('',(#3798));
#3800=FACE_BOUND('',#3799,.T.);
#3801=ORIENTED_EDGE('',*,*,#2356,.F.);
#3802=EDGE_LOOP('',(#3801));
#3803=FACE_BOUND('',#3802,.T.);
#3804=ADVANCED_FACE('F2000',(#3800,#3803),#3789,.F.);
#3805=CARTESIAN_POINT('',(0.,-4.3800000000104,-316.66666666667));
#3806=DIRECTION('',(0.,1.,0.));
#3807=DIRECTION('',(0.,0.,1.));
#3808=AXIS2_PLACEMENT_3D('',#3805,#3806,#3807);
#3809=CONICAL_SURFACE('',#3808,12.9999999999988,0.785398163397126);
#3810=CARTESIAN_POINT('',(0.,-4.38000000003483,-316.66666666667));
#3811=DIRECTION('',(0.,1.,0.));
#3812=DIRECTION('',(-1.,0.,0.));
#3813=AXIS2_PLACEMENT_3D('',#3810,#3811,#3812);
#3814=CIRCLE('',#3813,12.9999999999622);
#3815=CARTESIAN_POINT('',(-12.9999999999622,-4.38000000003483,-316.66666666667));
#3816=VERTEX_POINT('',#3815);
#3817=EDGE_CURVE('E889',#3816,#3816,#3814,.T.);
#3818=ORIENTED_EDGE('',*,*,#3817,.T.);
#3819=EDGE_LOOP('',(#3818));
#3820=FACE_BOUND('',#3819,.T.);
#3821=ORIENTED_EDGE('',*,*,#2376,.F.);
#3822=EDGE_LOOP('',(#3821));
#3823=FACE_BOUND('',#3822,.T.);
#3824=ADVANCED_FACE('F1997',(#3820,#3823),#3809,.F.);
#3825=CARTESIAN_POINT('',(-30.000000000007,-3.80000000000004,-594.999999999906));
#3826=DIRECTION('',(-0.707106781186498,-0.707106781186598,0.));
#3827=DIRECTION('',(0.707106781186598,-0.707106781186498,0.));
#3828=AXIS2_PLACEMENT_3D('',#3825,#3826,#3827);
#3829=PLANE('',#3828);
#3830=DIRECTION('',(0.,0.,-1.));
#3831=VECTOR('',#3830,1.);
#3832=CARTESIAN_POINT('',(-30.000000000007,-3.80000000000004,-594.999999999906));
#3833=LINE('',#3832,#3831);
#3834=CARTESIAN_POINT('',(-30.000000000007,-3.80000000000004,0.));
#3835=VERTEX_POINT('',#3834);
#3836=CARTESIAN_POINT('',(-30.000000000007,-3.80000000000004,-594.999999999906));
#3837=VERTEX_POINT('',#3836);
#3838=EDGE_CURVE('E886',#3835,#3837,#3833,.T.);
#3839=ORIENTED_EDGE('',*,*,#3838,.T.);
#3840=DIRECTION('',(-0.707106781185425,0.70710678118767,0.));
#3841=VECTOR('',#3840,1.);
#3842=CARTESIAN_POINT('',(-30.000000000007,-3.80000000000004,-594.999999999906));
#3843=LINE('',#3842,#3841);
#3844=EDGE_CURVE('E1004',#3837,#3265,#3843,.T.);
#3845=ORIENTED_EDGE('',*,*,#3844,.T.);
#3846=ORIENTED_EDGE('',*,*,#3266,.F.);
#3847=DIRECTION('',(-0.707106781185425,0.70710678118767,0.));
#3848=VECTOR('',#3847,1.);
#3849=CARTESIAN_POINT('',(-30.000000000007,-3.80000000000004,0.));
#3850=LINE('',#3849,#3848);
#3851=EDGE_CURVE('E920',#3835,#3263,#3850,.T.);
#3852=ORIENTED_EDGE('',*,*,#3851,.F.);
#3853=EDGE_LOOP('',(#3839,#3845,#3846,#3852));
#3854=FACE_BOUND('',#3853,.T.);
#3855=ADVANCED_FACE('F1879',(#3854),#3829,.F.);
#3856=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,-594.999999999906));
#3857=DIRECTION('',(0.,0.,1.));
#3858=DIRECTION('',(1.,0.,0.));
#3859=AXIS2_PLACEMENT_3D('',#3856,#3857,#3858);
#3860=PLANE('',#3859);
#3861=ORIENTED_EDGE('',*,*,#1287,.T.);
#3862=ORIENTED_EDGE('',*,*,#2629,.F.);
#3863=ORIENTED_EDGE('',*,*,#1125,.T.);
#3864=ORIENTED_EDGE('',*,*,#2615,.F.);
#3865=ORIENTED_EDGE('',*,*,#3660,.F.);
#3866=ORIENTED_EDGE('',*,*,#3625,.F.);
#3867=ORIENTED_EDGE('',*,*,#3594,.F.);
#3868=ORIENTED_EDGE('',*,*,#3563,.F.);
#3869=ORIENTED_EDGE('',*,*,#3538,.F.);
#3870=ORIENTED_EDGE('',*,*,#2591,.F.);
#3871=ORIENTED_EDGE('',*,*,#3458,.F.);
#3872=ORIENTED_EDGE('',*,*,#3429,.F.);
#3873=ORIENTED_EDGE('',*,*,#3398,.F.);
#3874=ORIENTED_EDGE('',*,*,#3367,.F.);
#3875=ORIENTED_EDGE('',*,*,#3336,.F.);
#3876=ORIENTED_EDGE('',*,*,#3305,.F.);
#3877=ORIENTED_EDGE('',*,*,#3274,.F.);
#3878=ORIENTED_EDGE('',*,*,#3844,.F.);
#3879=DIRECTION('',(1.,0.,0.));
#3880=VECTOR('',#3879,1.);
#3881=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,-594.999999999906));
#3882=LINE('',#3881,#3880);
#3883=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,-594.999999999906));
#3884=VERTEX_POINT('',#3883);
#3885=EDGE_CURVE('E883',#3837,#3884,#3882,.T.);
#3886=ORIENTED_EDGE('',*,*,#3885,.T.);
#3887=DIRECTION('',(0.707106781186598,0.707106781186498,0.));
#3888=VECTOR('',#3887,1.);
#3889=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,-594.999999999906));
#3890=LINE('',#3889,#3888);
#3891=EDGE_CURVE('E955',#3884,#3233,#3890,.T.);
#3892=ORIENTED_EDGE('',*,*,#3891,.T.);
#3893=ORIENTED_EDGE('',*,*,#3234,.F.);
#3894=ORIENTED_EDGE('',*,*,#3203,.F.);
#3895=ORIENTED_EDGE('',*,*,#3172,.F.);
#3896=ORIENTED_EDGE('',*,*,#3141,.F.);
#3897=ORIENTED_EDGE('',*,*,#3110,.F.);
#3898=ORIENTED_EDGE('',*,*,#3079,.F.);
#3899=ORIENTED_EDGE('',*,*,#3048,.F.);
#3900=ORIENTED_EDGE('',*,*,#2557,.F.);
#3901=ORIENTED_EDGE('',*,*,#2996,.F.);
#3902=ORIENTED_EDGE('',*,*,#2961,.F.);
#3903=ORIENTED_EDGE('',*,*,#2930,.F.);
#3904=ORIENTED_EDGE('',*,*,#2899,.F.);
#3905=ORIENTED_EDGE('',*,*,#2874,.F.);
#3906=ORIENTED_EDGE('',*,*,#2523,.F.);
#3907=ORIENTED_EDGE('',*,*,#1045,.T.);
#3908=ORIENTED_EDGE('',*,*,#2499,.F.);
#3909=ORIENTED_EDGE('',*,*,#982,.T.);
#3910=ORIENTED_EDGE('',*,*,#2477,.F.);
#3911=ORIENTED_EDGE('',*,*,#2455,.F.);
#3912=ORIENTED_EDGE('',*,*,#2431,.F.);
#3913=ORIENTED_EDGE('',*,*,#2404,.F.);
#3914=ORIENTED_EDGE('',*,*,#2648,.F.);
#3915=EDGE_LOOP('',(#3861,#3862,#3863,#3864,#3865,#3866,#3867,#3868,#3869,#3870,#3871,#3872,
#3873,#3874,#3875,#3876,#3877,#3878,#3886,#3892,#3893,#3894,#3895,#3896,#3897,#3898,#3899,#3900,
#3901,#3902,#3903,#3904,#3905,#3906,#3907,#3908,#3909,#3910,#3911,#3912,#3913,#3914));
#3916=FACE_BOUND('',#3915,.T.);
#3917=ADVANCED_FACE('F1651',(#3916),#3860,.F.);
#3918=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,-594.999999999906));
#3919=DIRECTION('',(0.707106781186498,-0.707106781186598,0.));
#3920=DIRECTION('',(0.707106781186598,0.707106781186498,0.));
#3921=AXIS2_PLACEMENT_3D('',#3918,#3919,#3920);
#3922=PLANE('',#3921);
#3923=ORIENTED_EDGE('',*,*,#3242,.F.);
#3924=ORIENTED_EDGE('',*,*,#3891,.F.);
#3925=DIRECTION('',(0.,0.,-1.));
#3926=VECTOR('',#3925,1.);
#3927=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,-594.999999999906));
#3928=LINE('',#3927,#3926);
#3929=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,0.));
#3930=VERTEX_POINT('',#3929);
#3931=EDGE_CURVE('E880',#3884,#3930,#3928,.F.);
#3932=ORIENTED_EDGE('',*,*,#3931,.T.);
#3933=DIRECTION('',(-0.707106781185428,-0.707106781187667,0.));
#3934=VECTOR('',#3933,1.);
#3935=CARTESIAN_POINT('',(30.8000000000038,-3.0000000000007,0.));
#3936=LINE('',#3935,#3934);
#3937=EDGE_CURVE('E53',#3241,#3930,#3936,.T.);
#3938=ORIENTED_EDGE('',*,*,#3937,.F.);
#3939=EDGE_LOOP('',(#3923,#3924,#3932,#3938));
#3940=FACE_BOUND('',#3939,.T.);
#3941=ADVANCED_FACE('F1886',(#3940),#3922,.F.);
#3942=CARTESIAN_POINT('',(-84.9999999999902,-35.0000000000124,0.));
#3943=DIRECTION('',(0.,0.,1.));
#3944=DIRECTION('',(1.,0.,0.));
#3945=AXIS2_PLACEMENT_3D('',#3942,#3943,#3944);
#3946=PLANE('',#3945);
#3947=ORIENTED_EDGE('',*,*,#2252,.T.);
#3948=ORIENTED_EDGE('',*,*,#3700,.T.);
#3949=ORIENTED_EDGE('',*,*,#2163,.T.);
#3950=ORIENTED_EDGE('',*,*,#2680,.T.);
#3951=ORIENTED_EDGE('',*,*,#2704,.T.);
#3952=ORIENTED_EDGE('',*,*,#2749,.T.);
#3953=ORIENTED_EDGE('',*,*,#2767,.T.);
#3954=ORIENTED_EDGE('',*,*,#2791,.T.);
#3955=ORIENTED_EDGE('',*,*,#1614,.T.);
#3956=ORIENTED_EDGE('',*,*,#2815,.T.);
#3957=ORIENTED_EDGE('',*,*,#1646,.T.);
#3958=ORIENTED_EDGE('',*,*,#2839,.T.);
#3959=ORIENTED_EDGE('',*,*,#2863,.T.);
#3960=ORIENTED_EDGE('',*,*,#2890,.T.);
#3961=ORIENTED_EDGE('',*,*,#2921,.T.);
#3962=ORIENTED_EDGE('',*,*,#2952,.T.);
#3963=ORIENTED_EDGE('',*,*,#2989,.T.);
#3964=ORIENTED_EDGE('',*,*,#3027,.T.);
#3965=ORIENTED_EDGE('',*,*,#3062,.T.);
#3966=ORIENTED_EDGE('',*,*,#3093,.T.);
#3967=ORIENTED_EDGE('',*,*,#3124,.T.);
#3968=ORIENTED_EDGE('',*,*,#3155,.T.);
#3969=ORIENTED_EDGE('',*,*,#3186,.T.);
#3970=ORIENTED_EDGE('',*,*,#3217,.T.);
#3971=ORIENTED_EDGE('',*,*,#3248,.T.);
#3972=ORIENTED_EDGE('',*,*,#3937,.T.);
#3973=DIRECTION('',(1.,0.,0.));
#3974=VECTOR('',#3973,1.);
#3975=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,0.));
#3976=LINE('',#3975,#3974);
#3977=EDGE_CURVE('E687',#3930,#3835,#3976,.F.);
#3978=ORIENTED_EDGE('',*,*,#3977,.T.);
#3979=ORIENTED_EDGE('',*,*,#3851,.T.);
#3980=ORIENTED_EDGE('',*,*,#3288,.T.);
#3981=ORIENTED_EDGE('',*,*,#3319,.T.);
#3982=ORIENTED_EDGE('',*,*,#3350,.T.);
#3983=ORIENTED_EDGE('',*,*,#3381,.T.);
#3984=ORIENTED_EDGE('',*,*,#3412,.T.);
#3985=ORIENTED_EDGE('',*,*,#3443,.T.);
#3986=ORIENTED_EDGE('',*,*,#3476,.T.);
#3987=ORIENTED_EDGE('',*,*,#3503,.T.);
#3988=ORIENTED_EDGE('',*,*,#3527,.T.);
#3989=ORIENTED_EDGE('',*,*,#3554,.T.);
#3990=ORIENTED_EDGE('',*,*,#3585,.T.);
#3991=ORIENTED_EDGE('',*,*,#3616,.T.);
#3992=ORIENTED_EDGE('',*,*,#3653,.T.);
#3993=ORIENTED_EDGE('',*,*,#3681,.T.);
#3994=EDGE_LOOP('',(#3947,#3948,#3949,#3950,#3951,#3952,#3953,#3954,#3955,#3956,#3957,#3958,
#3959,#3960,#3961,#3962,#3963,#3964,#3965,#3966,#3967,#3968,#3969,#3970,#3971,#3972,#3978,#3979,
#3980,#3981,#3982,#3983,#3984,#3985,#3986,#3987,#3988,#3989,#3990,#3991,#3992,#3993));
#3995=FACE_BOUND('',#3994,.T.);
#3996=ADVANCED_FACE('F1714',(#3995),#3946,.T.);
#3997=CARTESIAN_POINT('',(0.,-3.80000000001368,-69.0000000000034));
#3998=DIRECTION('',(0.,1.,0.));
#3999=DIRECTION('',(0.,0.,1.));
#4000=AXIS2_PLACEMENT_3D('',#3997,#3998,#3999);
#4001=CONICAL_SURFACE('',#4000,13.9999999999953,1.04521253324296);
#4002=CARTESIAN_POINT('',(0.,-3.80000000001367,-69.0000000000034));
#4003=DIRECTION('',(0.,1.,0.));
#4004=DIRECTION('',(0.,0.,1.));
#4005=AXIS2_PLACEMENT_3D('',#4002,#4003,#4004);
#4006=CIRCLE('',#4005,13.9999999999953);
#4007=CARTESIAN_POINT('',(0.,-3.80000000001367,-55.000000000008));
#4008=VERTEX_POINT('',#4007);
#4009=EDGE_CURVE('E684',#4008,#4008,#4006,.T.);
#4010=ORIENTED_EDGE('',*,*,#4009,.T.);
#4011=EDGE_LOOP('',(#4010));
#4012=FACE_BOUND('',#4011,.T.);
#4013=ORIENTED_EDGE('',*,*,#3717,.F.);
#4014=EDGE_LOOP('',(#4013));
#4015=FACE_BOUND('',#4014,.T.);
#4016=ADVANCED_FACE('F1984',(#4012,#4015),#4001,.F.);
#4017=CARTESIAN_POINT('',(0.,-3.80000000001368,-109.499999999994));
#4018=DIRECTION('',(0.,1.,0.));
#4019=DIRECTION('',(0.,0.,1.));
#4020=AXIS2_PLACEMENT_3D('',#4017,#4018,#4019);
#4021=CONICAL_SURFACE('',#4020,13.9999999999953,1.04521253324296);
#4022=CARTESIAN_POINT('',(0.,-3.80000000001368,-109.499999999994));
#4023=DIRECTION('',(0.,1.,0.));
#4024=DIRECTION('',(0.,0.,1.));
#4025=AXIS2_PLACEMENT_3D('',#4022,#4023,#4024);
#4026=CIRCLE('',#4025,13.9999999999953);
#4027=CARTESIAN_POINT('',(0.,-3.80000000001368,-95.4999999999985));
#4028=VERTEX_POINT('',#4027);
#4029=EDGE_CURVE('E681',#4028,#4028,#4026,.T.);
#4030=ORIENTED_EDGE('',*,*,#4029,.T.);
#4031=EDGE_LOOP('',(#4030));
#4032=FACE_BOUND('',#4031,.T.);
#4033=ORIENTED_EDGE('',*,*,#3737,.F.);
#4034=EDGE_LOOP('',(#4033));
#4035=FACE_BOUND('',#4034,.T.);
#4036=ADVANCED_FACE('F1980',(#4032,#4035),#4021,.F.);
#4037=CARTESIAN_POINT('',(0.,-3.80000000000136,-183.333333333311));
#4038=DIRECTION('',(0.,1.,0.));
#4039=DIRECTION('',(-1.,0.,0.));
#4040=AXIS2_PLACEMENT_3D('',#4037,#4038,#4039);
#4041=CONICAL_SURFACE('',#4040,14.0000000000166,1.04521253324296);
#4042=CARTESIAN_POINT('',(0.,-3.80000000001368,-183.333333333311));
#4043=DIRECTION('',(0.,1.,0.));
#4044=DIRECTION('',(-1.,0.,0.));
#4045=AXIS2_PLACEMENT_3D('',#4042,#4043,#4044);
#4046=CIRCLE('',#4045,13.9999999999953);
#4047=CARTESIAN_POINT('',(-13.9999999999953,-3.80000000001368,-183.333333333311));
#4048=VERTEX_POINT('',#4047);
#4049=EDGE_CURVE('E678',#4048,#4048,#4046,.T.);
#4050=ORIENTED_EDGE('',*,*,#4049,.T.);
#4051=EDGE_LOOP('',(#4050));
#4052=FACE_BOUND('',#4051,.T.);
#4053=ORIENTED_EDGE('',*,*,#3757,.F.);
#4054=EDGE_LOOP('',(#4053));
#4055=FACE_BOUND('',#4054,.T.);
#4056=ADVANCED_FACE('F1976',(#4052,#4055),#4041,.F.);
#4057=CARTESIAN_POINT('',(0.,-3.80000000001368,-216.666666666689));
#4058=DIRECTION('',(0.,1.,0.));
#4059=DIRECTION('',(-1.,0.,0.));
#4060=AXIS2_PLACEMENT_3D('',#4057,#4058,#4059);
#4061=CONICAL_SURFACE('',#4060,13.9999999999953,1.04521253324296);
#4062=CARTESIAN_POINT('',(0.,-3.80000000000267,-216.666666666689));
#4063=DIRECTION('',(0.,1.,0.));
#4064=DIRECTION('',(-1.,0.,0.));
#4065=AXIS2_PLACEMENT_3D('',#4062,#4063,#4064);
#4066=CIRCLE('',#4065,14.0000000000143);
#4067=CARTESIAN_POINT('',(-14.0000000000143,-3.80000000000267,-216.666666666689));
#4068=VERTEX_POINT('',#4067);
#4069=EDGE_CURVE('E675',#4068,#4068,#4066,.T.);
#4070=ORIENTED_EDGE('',*,*,#4069,.T.);
#4071=EDGE_LOOP('',(#4070));
#4072=FACE_BOUND('',#4071,.T.);
#4073=ORIENTED_EDGE('',*,*,#3777,.F.);
#4074=EDGE_LOOP('',(#4073));
#4075=FACE_BOUND('',#4074,.T.);
#4076=ADVANCED_FACE('F1972',(#4072,#4075),#4061,.F.);
#4077=CARTESIAN_POINT('',(0.,-3.80000000003573,-283.333333333216));
#4078=DIRECTION('',(0.,1.,0.));
#4079=DIRECTION('',(0.,0.,1.));
#4080=AXIS2_PLACEMENT_3D('',#4077,#4078,#4079);
#4081=CONICAL_SURFACE('',#4080,13.9999999999573,1.04521253324296);
#4082=CARTESIAN_POINT('',(0.,-3.79999999992549,-283.333333333216));
#4083=DIRECTION('',(0.,1.,0.));
#4084=DIRECTION('',(-1.,0.,0.));
#4085=AXIS2_PLACEMENT_3D('',#4082,#4083,#4084);
#4086=CIRCLE('',#4085,14.0000000001474);
#4087=CARTESIAN_POINT('',(-14.0000000001474,-3.79999999992549,-283.333333333216));
#4088=VERTEX_POINT('',#4087);
#4089=EDGE_CURVE('E44',#4088,#4088,#4086,.T.);
#4090=ORIENTED_EDGE('',*,*,#4089,.T.);
#4091=EDGE_LOOP('',(#4090));
#4092=FACE_BOUND('',#4091,.T.);
#4093=ORIENTED_EDGE('',*,*,#3797,.F.);
#4094=EDGE_LOOP('',(#4093));
#4095=FACE_BOUND('',#4094,.T.);
#4096=ADVANCED_FACE('F1963',(#4092,#4095),#4081,.F.);
#4097=CARTESIAN_POINT('',(0.,-3.80000000001083,-316.66666666667));
#4098=DIRECTION('',(0.,1.,0.));
#4099=DIRECTION('',(0.,0.,1.));
#4100=AXIS2_PLACEMENT_3D('',#4097,#4098,#4099);
#4101=CONICAL_SURFACE('',#4100,14.0000000000028,1.04521253324296);
#4102=CARTESIAN_POINT('',(0.,-3.80000000001083,-316.66666666667));
#4103=DIRECTION('',(0.,1.,0.));
#4104=DIRECTION('',(0.,0.,1.));
#4105=AXIS2_PLACEMENT_3D('',#4102,#4103,#4104);
#4106=CIRCLE('',#4105,14.0000000000028);
#4107=CARTESIAN_POINT('',(0.,-3.80000000001083,-302.666666666667));
#4108=VERTEX_POINT('',#4107);
#4109=EDGE_CURVE('E11',#4108,#4108,#4106,.T.);
#4110=ORIENTED_EDGE('',*,*,#4109,.T.);
#4111=EDGE_LOOP('',(#4110));
#4112=FACE_BOUND('',#4111,.T.);
#4113=ORIENTED_EDGE('',*,*,#3817,.F.);
#4114=EDGE_LOOP('',(#4113));
#4115=FACE_BOUND('',#4114,.T.);
#4116=ADVANCED_FACE('F1953',(#4112,#4115),#4101,.F.);
#4117=CARTESIAN_POINT('',(30.000000000007,-3.80000000000004,-594.999999999906));
#4118=DIRECTION('',(0.,-1.,0.));
#4119=DIRECTION('',(0.,0.,-1.));
#4120=AXIS2_PLACEMENT_3D('',#4117,#4118,#4119);
#4121=PLANE('',#4120);
#4122=CARTESIAN_POINT('',(0.,-3.80000000000004,-349.999999999906));
#4123=DIRECTION('',(0.,1.,0.));
#4124=DIRECTION('',(0.,0.,1.));
#4125=AXIS2_PLACEMENT_3D('',#4122,#4123,#4124);
#4126=CIRCLE('',#4125,13.);
#4127=CARTESIAN_POINT('',(0.,-3.80000000000004,-336.999999999906));
#4128=VERTEX_POINT('',#4127);
#4129=EDGE_CURVE('E2856',#4128,#4128,#4126,.T.);
#4130=ORIENTED_EDGE('',*,*,#4129,.F.);
#4131=EDGE_LOOP('',(#4130));
#4132=FACE_BOUND('',#4131,.T.);
#4133=CARTESIAN_POINT('',(0.,-3.80000000000004,-149.999999999906));
#4134=DIRECTION('',(0.,1.,0.));
#4135=DIRECTION('',(0.,0.,1.));
#4136=AXIS2_PLACEMENT_3D('',#4133,#4134,#4135);
#4137=CIRCLE('',#4136,13.);
#4138=CARTESIAN_POINT('',(0.,-3.80000000000004,-136.999999999906));
#4139=VERTEX_POINT('',#4138);
#4140=EDGE_CURVE('E864',#4139,#4139,#4137,.T.);
#4141=ORIENTED_EDGE('',*,*,#4140,.F.);
#4142=EDGE_LOOP('',(#4141));
#4143=FACE_BOUND('',#4142,.T.);
#4144=CARTESIAN_POINT('',(0.,-3.80000000000004,-449.999999999906));
#4145=DIRECTION('',(0.,1.,0.));
#4146=DIRECTION('',(0.,0.,1.));
#4147=AXIS2_PLACEMENT_3D('',#4144,#4145,#4146);
#4148=CIRCLE('',#4147,13.);
#4149=CARTESIAN_POINT('',(0.,-3.80000000000004,-436.999999999906));
#4150=VERTEX_POINT('',#4149);
#4151=EDGE_CURVE('E851',#4150,#4150,#4148,.T.);
#4152=ORIENTED_EDGE('',*,*,#4151,.F.);
#4153=EDGE_LOOP('',(#4152));
#4154=FACE_BOUND('',#4153,.T.);
#4155=CARTESIAN_POINT('',(0.,-3.80000000000004,-249.999999999906));
#4156=DIRECTION('',(0.,1.,0.));
#4157=DIRECTION('',(0.,0.,1.));
#4158=AXIS2_PLACEMENT_3D('',#4155,#4156,#4157);
#4159=CIRCLE('',#4158,13.);
#4160=CARTESIAN_POINT('',(0.,-3.80000000000004,-236.999999999906));
#4161=VERTEX_POINT('',#4160);
#4162=EDGE_CURVE('E847',#4161,#4161,#4159,.T.);
#4163=ORIENTED_EDGE('',*,*,#4162,.F.);
#4164=EDGE_LOOP('',(#4163));
#4165=FACE_BOUND('',#4164,.T.);
#4166=ORIENTED_EDGE('',*,*,#4109,.F.);
#4167=EDGE_LOOP('',(#4166));
#4168=FACE_BOUND('',#4167,.T.);
#4169=ORIENTED_EDGE('',*,*,#4089,.F.);
#4170=EDGE_LOOP('',(#4169));
#4171=FACE_BOUND('',#4170,.T.);
#4172=ORIENTED_EDGE('',*,*,#4069,.F.);
#4173=EDGE_LOOP('',(#4172));
#4174=FACE_BOUND('',#4173,.T.);
#4175=ORIENTED_EDGE('',*,*,#4049,.F.);
#4176=EDGE_LOOP('',(#4175));
#4177=FACE_BOUND('',#4176,.T.);
#4178=ORIENTED_EDGE('',*,*,#4029,.F.);
#4179=EDGE_LOOP('',(#4178));
#4180=FACE_BOUND('',#4179,.T.);
#4181=ORIENTED_EDGE('',*,*,#4009,.F.);
#4182=EDGE_LOOP('',(#4181));
#4183=FACE_BOUND('',#4182,.T.);
#4184=ORIENTED_EDGE('',*,*,#3931,.F.);
#4185=ORIENTED_EDGE('',*,*,#3885,.F.);
#4186=ORIENTED_EDGE('',*,*,#3838,.F.);
#4187=ORIENTED_EDGE('',*,*,#3977,.F.);
#4188=EDGE_LOOP('',(#4184,#4185,#4186,#4187));
#4189=FACE_BOUND('',#4188,.T.);
#4190=ADVANCED_FACE('F1882',(#4132,#4143,#4154,#4165,#4168,#4171,#4174,#4177,#4180,#4183,#4189),
#4121,.F.);
#4191=CARTESIAN_POINT('',(0.,-3.80000000000004,-249.999999999906));
#4192=DIRECTION('',(0.,1.,0.));
#4193=DIRECTION('',(0.,0.,1.));
#4194=AXIS2_PLACEMENT_3D('',#4191,#4192,#4193);
#4195=CYLINDRICAL_SURFACE('',#4194,8.50000000000001);
#4196=ORIENTED_EDGE('',*,*,#2733,.T.);
#4197=EDGE_LOOP('',(#4196));
#4198=FACE_BOUND('',#4197,.T.);
#4199=CARTESIAN_POINT('',(0.,-20.8,-249.999999999906));
#4200=DIRECTION('',(0.,1.,0.));
#4201=DIRECTION('',(0.,0.,1.));
#4202=AXIS2_PLACEMENT_3D('',#4199,#4200,#4201);
#4203=CIRCLE('',#4202,8.50000000000001);
#4204=CARTESIAN_POINT('',(0.,-20.8,-241.499999999906));
#4205=VERTEX_POINT('',#4204);
#4206=EDGE_CURVE('E844',#4205,#4205,#4203,.T.);
#4207=ORIENTED_EDGE('',*,*,#4206,.T.);
#4208=EDGE_LOOP('',(#4207));
#4209=FACE_BOUND('',#4208,.T.);
#4210=ADVANCED_FACE('F1952',(#4198,#4209),#4195,.F.);
#4211=CARTESIAN_POINT('',(8.50000000000001,-20.8,-249.999999999906));
#4212=DIRECTION('',(0.,-1.,0.));
#4213=DIRECTION('',(0.,0.,-1.));
#4214=AXIS2_PLACEMENT_3D('',#4211,#4212,#4213);
#4215=PLANE('',#4214);
#4216=ORIENTED_EDGE('',*,*,#4206,.F.);
#4217=EDGE_LOOP('',(#4216));
#4218=FACE_BOUND('',#4217,.T.);
#4219=CARTESIAN_POINT('',(0.,-20.8,-249.999999999906));
#4220=DIRECTION('',(0.,1.,0.));
#4221=DIRECTION('',(0.,0.,1.));
#4222=AXIS2_PLACEMENT_3D('',#4219,#4220,#4221);
#4223=CIRCLE('',#4222,13.);
#4224=CARTESIAN_POINT('',(0.,-20.8,-236.999999999906));
#4225=VERTEX_POINT('',#4224);
#4226=EDGE_CURVE('E874',#4225,#4225,#4223,.T.);
#4227=ORIENTED_EDGE('',*,*,#4226,.T.);
#4228=EDGE_LOOP('',(#4227));
#4229=FACE_BOUND('',#4228,.T.);
#4230=ADVANCED_FACE('F1960',(#4218,#4229),#4215,.F.);
#4231=CARTESIAN_POINT('',(0.,-3.80000000000004,-249.999999999906));
#4232=DIRECTION('',(0.,1.,0.));
#4233=DIRECTION('',(0.,0.,1.));
#4234=AXIS2_PLACEMENT_3D('',#4231,#4232,#4233);
#4235=CYLINDRICAL_SURFACE('',#4234,13.);
#4236=ORIENTED_EDGE('',*,*,#4226,.F.);
#4237=EDGE_LOOP('',(#4236));
#4238=FACE_BOUND('',#4237,.T.);
#4239=ORIENTED_EDGE('',*,*,#4162,.T.);
#4240=EDGE_LOOP('',(#4239));
#4241=FACE_BOUND('',#4240,.T.);
#4242=ADVANCED_FACE('F2761',(#4238,#4241),#4235,.F.);
#4243=CARTESIAN_POINT('',(0.,-3.80000000000004,-449.999999999906));
#4244=DIRECTION('',(0.,1.,0.));
#4245=DIRECTION('',(0.,0.,1.));
#4246=AXIS2_PLACEMENT_3D('',#4243,#4244,#4245);
#4247=CYLINDRICAL_SURFACE('',#4246,8.50000000000001);
#4248=ORIENTED_EDGE('',*,*,#795,.T.);
#4249=EDGE_LOOP('',(#4248));
#4250=FACE_BOUND('',#4249,.T.);
#4251=CARTESIAN_POINT('',(0.,-20.8,-449.999999999906));
#4252=DIRECTION('',(0.,1.,0.));
#4253=DIRECTION('',(0.,0.,1.));
#4254=AXIS2_PLACEMENT_3D('',#4251,#4252,#4253);
#4255=CIRCLE('',#4254,8.50000000000001);
#4256=CARTESIAN_POINT('',(0.,-20.8,-441.499999999906));
#4257=VERTEX_POINT('',#4256);
#4258=EDGE_CURVE('E848',#4257,#4257,#4255,.T.);
#4259=ORIENTED_EDGE('',*,*,#4258,.T.);
#4260=EDGE_LOOP('',(#4259));
#4261=FACE_BOUND('',#4260,.T.);
#4262=ADVANCED_FACE('F2751',(#4250,#4261),#4247,.F.);
#4263=CARTESIAN_POINT('',(8.50000000000001,-20.8,-449.999999999906));
#4264=DIRECTION('',(0.,-1.,0.));
#4265=DIRECTION('',(0.,0.,-1.));
#4266=AXIS2_PLACEMENT_3D('',#4263,#4264,#4265);
#4267=PLANE('',#4266);
#4268=ORIENTED_EDGE('',*,*,#4258,.F.);
#4269=EDGE_LOOP('',(#4268));
#4270=FACE_BOUND('',#4269,.T.);
#4271=CARTESIAN_POINT('',(0.,-20.8,-449.999999999906));
#4272=DIRECTION('',(0.,1.,0.));
#4273=DIRECTION('',(0.,0.,1.));
#4274=AXIS2_PLACEMENT_3D('',#4271,#4272,#4273);
#4275=CIRCLE('',#4274,13.);
#4276=CARTESIAN_POINT('',(0.,-20.8,-436.999999999906));
#4277=VERTEX_POINT('',#4276);
#4278=EDGE_CURVE('E856',#4277,#4277,#4275,.T.);
#4279=ORIENTED_EDGE('',*,*,#4278,.T.);
#4280=EDGE_LOOP('',(#4279));
#4281=FACE_BOUND('',#4280,.T.);
#4282=ADVANCED_FACE('F2739',(#4270,#4281),#4267,.F.);
#4283=CARTESIAN_POINT('',(0.,-3.80000000000004,-449.999999999906));
#4284=DIRECTION('',(0.,1.,0.));
#4285=DIRECTION('',(0.,0.,1.));
#4286=AXIS2_PLACEMENT_3D('',#4283,#4284,#4285);
#4287=CYLINDRICAL_SURFACE('',#4286,13.);
#4288=ORIENTED_EDGE('',*,*,#4278,.F.);
#4289=EDGE_LOOP('',(#4288));
#4290=FACE_BOUND('',#4289,.T.);
#4291=ORIENTED_EDGE('',*,*,#4151,.T.);
#4292=EDGE_LOOP('',(#4291));
#4293=FACE_BOUND('',#4292,.T.);
#4294=ADVANCED_FACE('F2733',(#4290,#4293),#4287,.F.);
#4295=CARTESIAN_POINT('',(0.,-3.80000000000004,-149.999999999906));
#4296=DIRECTION('',(0.,1.,0.));
#4297=DIRECTION('',(0.,0.,1.));
#4298=AXIS2_PLACEMENT_3D('',#4295,#4296,#4297);
#4299=CYLINDRICAL_SURFACE('',#4298,8.00000000000001);
#4300=ORIENTED_EDGE('',*,*,#2722,.T.);
#4301=EDGE_LOOP('',(#4300));
#4302=FACE_BOUND('',#4301,.T.);
#4303=CARTESIAN_POINT('',(0.,-14.8,-149.999999999906));
#4304=DIRECTION('',(0.,1.,0.));
#4305=DIRECTION('',(0.,0.,1.));
#4306=AXIS2_PLACEMENT_3D('',#4303,#4304,#4305);
#4307=CIRCLE('',#4306,8.00000000000001);
#4308=CARTESIAN_POINT('',(0.,-14.8,-141.999999999906));
#4309=VERTEX_POINT('',#4308);
#4310=EDGE_CURVE('E852',#4309,#4309,#4307,.T.);
#4311=ORIENTED_EDGE('',*,*,#4310,.T.);
#4312=EDGE_LOOP('',(#4311));
#4313=FACE_BOUND('',#4312,.T.);
#4314=ADVANCED_FACE('F2738',(#4302,#4313),#4299,.F.);
#4315=CARTESIAN_POINT('',(8.00000000000001,-14.8,-149.999999999906));
#4316=DIRECTION('',(0.,-1.,0.));
#4317=DIRECTION('',(0.,0.,-1.));
#4318=AXIS2_PLACEMENT_3D('',#4315,#4316,#4317);
#4319=PLANE('',#4318);
#4320=ORIENTED_EDGE('',*,*,#4310,.F.);
#4321=EDGE_LOOP('',(#4320));
#4322=FACE_BOUND('',#4321,.T.);
#4323=CARTESIAN_POINT('',(0.,-14.8,-149.999999999906));
#4324=DIRECTION('',(0.,1.,0.));
#4325=DIRECTION('',(0.,0.,1.));
#4326=AXIS2_PLACEMENT_3D('',#4323,#4324,#4325);
#4327=CIRCLE('',#4326,13.);
#4328=CARTESIAN_POINT('',(0.,-14.8,-136.999999999906));
#4329=VERTEX_POINT('',#4328);
#4330=EDGE_CURVE('E859',#4329,#4329,#4327,.T.);
#4331=ORIENTED_EDGE('',*,*,#4330,.T.);
#4332=EDGE_LOOP('',(#4331));
#4333=FACE_BOUND('',#4332,.T.);
#4334=ADVANCED_FACE('F2798',(#4322,#4333),#4319,.F.);
#4335=CARTESIAN_POINT('',(0.,-3.80000000000004,-149.999999999906));
#4336=DIRECTION('',(0.,1.,0.));
#4337=DIRECTION('',(0.,0.,1.));
#4338=AXIS2_PLACEMENT_3D('',#4335,#4336,#4337);
#4339=CYLINDRICAL_SURFACE('',#4338,13.);
#4340=ORIENTED_EDGE('',*,*,#4330,.F.);
#4341=EDGE_LOOP('',(#4340));
#4342=FACE_BOUND('',#4341,.T.);
#4343=ORIENTED_EDGE('',*,*,#4140,.T.);
#4344=EDGE_LOOP('',(#4343));
#4345=FACE_BOUND('',#4344,.T.);
#4346=ADVANCED_FACE('F2807',(#4342,#4345),#4339,.F.);
#4347=CARTESIAN_POINT('',(0.,-3.80000000000004,-349.999999999906));
#4348=DIRECTION('',(0.,1.,0.));
#4349=DIRECTION('',(0.,0.,1.));
#4350=AXIS2_PLACEMENT_3D('',#4347,#4348,#4349);
#4351=CYLINDRICAL_SURFACE('',#4350,8.00000000000001);
#4352=ORIENTED_EDGE('',*,*,#784,.T.);
#4353=EDGE_LOOP('',(#4352));
#4354=FACE_BOUND('',#4353,.T.);
#4355=CARTESIAN_POINT('',(0.,-14.8,-349.999999999906));
#4356=DIRECTION('',(0.,1.,0.));
#4357=DIRECTION('',(0.,0.,1.));
#4358=AXIS2_PLACEMENT_3D('',#4355,#4356,#4357);
#4359=CIRCLE('',#4358,8.00000000000001);
#4360=CARTESIAN_POINT('',(0.,-14.8,-341.999999999906));
#4361=VERTEX_POINT('',#4360);
#4362=EDGE_CURVE('E2858',#4361,#4361,#4359,.T.);
#4363=ORIENTED_EDGE('',*,*,#4362,.T.);
#4364=EDGE_LOOP('',(#4363));
#4365=FACE_BOUND('',#4364,.T.);
#4366=ADVANCED_FACE('F2817',(#4354,#4365),#4351,.F.);
#4367=CARTESIAN_POINT('',(8.00000000000001,-14.8,-349.999999999906));
#4368=DIRECTION('',(0.,-1.,0.));
#4369=DIRECTION('',(0.,0.,-1.));
#4370=AXIS2_PLACEMENT_3D('',#4367,#4368,#4369);
#4371=PLANE('',#4370);
#4372=ORIENTED_EDGE('',*,*,#4362,.F.);
#4373=EDGE_LOOP('',(#4372));
#4374=FACE_BOUND('',#4373,.T.);
#4375=CARTESIAN_POINT('',(0.,-14.8,-349.999999999906));
#4376=DIRECTION('',(0.,1.,0.));
#4377=DIRECTION('',(0.,0.,1.));
#4378=AXIS2_PLACEMENT_3D('',#4375,#4376,#4377);
#4379=CIRCLE('',#4378,13.);
#4380=CARTESIAN_POINT('',(0.,-14.8,-336.999999999906));
#4381=VERTEX_POINT('',#4380);
#4382=EDGE_CURVE('E2854',#4381,#4381,#4379,.T.);
#4383=ORIENTED_EDGE('',*,*,#4382,.T.);
#4384=EDGE_LOOP('',(#4383));
#4385=FACE_BOUND('',#4384,.T.);
#4386=ADVANCED_FACE('F2827',(#4374,#4385),#4371,.F.);
#4387=CARTESIAN_POINT('',(0.,-3.80000000000004,-349.999999999906));
#4388=DIRECTION('',(0.,1.,0.));
#4389=DIRECTION('',(0.,0.,1.));
#4390=AXIS2_PLACEMENT_3D('',#4387,#4388,#4389);
#4391=CYLINDRICAL_SURFACE('',#4390,13.);
#4392=ORIENTED_EDGE('',*,*,#4382,.F.);
#4393=EDGE_LOOP('',(#4392));
#4394=FACE_BOUND('',#4393,.T.);
#4395=ORIENTED_EDGE('',*,*,#4129,.T.);
#4396=EDGE_LOOP('',(#4395));
#4397=FACE_BOUND('',#4396,.T.);
#4398=ADVANCED_FACE('F2837',(#4394,#4397),#4391,.F.);
#4399=CLOSED_SHELL('',(#39,#60,#81,#102,#123,#143,#164,#185,#205,#225,#245,#265,#293,#313,#333,
#353,#373,#461,#481,#501,#521,#566,#586,#606,#626,#646,#667,#688,#709,#730,#751,#771,#901,#921,
#952,#992,#1023,#1063,#1083,#1103,#1143,#1202,#1226,#1266,#1297,#1328,#1359,#1418,#1442,#1477,
#1501,#1560,#1593,#1624,#1664,#1702,#1729,#1760,#1780,#1820,#1851,#1882,#1902,#1942,#1973,#2004,
#2051,#2086,#2133,#2173,#2204,#2232,#2263,#2283,#2303,#2323,#2343,#2363,#2383,#2414,#2441,#2465,
#2484,#2503,#2527,#2561,#2595,#2619,#2638,#2657,#2685,#2709,#2755,#2779,#2800,#2819,#2843,#2878,
#2909,#2940,#2971,#3004,#3031,#3066,#3097,#3128,#3159,#3190,#3221,#3252,#3292,#3323,#3354,#3385,
#3416,#3447,#3480,#3507,#3542,#3573,#3604,#3635,#3668,#3685,#3704,#3724,#3744,#3764,#3784,#3804,
#3824,#3855,#3917,#3941,#3996,#4016,#4036,#4056,#4076,#4096,#4116,#4190,#4210,#4230,#4242,#4262,
#4282,#4294,#4314,#4334,#4346,#4366,#4386,#4398));
#4400=MANIFOLD_SOLID_BREP('B2',#4399);
#4401=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#4400),#14);
#4402=SHAPE_DEFINITION_REPRESENTATION(#9,#4401);
ENDSEC;
END-ISO-10303-21;
